v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 80 -680 100 -680 {
lab=P0}
N 80 -660 100 -660 {
lab=P1}
N 80 -640 100 -640 {
lab=RST_DIV}
N 400 -640 420 -640 {
lab=VSS}
N 400 -660 420 -660 {
lab=VDD}
N 410 -1210 410 -1200 {
lab=VSS}
N 410 -1290 410 -1270 {
lab=P1}
N 510 -1210 510 -1200 {
lab=VSS}
N 510 -1290 510 -1270 {
lab=P0}
N 680 -740 680 -720 {
lab=VDD}
N 680 -590 680 -570 {
lab=VSS}
N 590 -680 610 -680 {
lab=#net1}
N 590 -630 610 -630 {
lab=#net2}
N 750 -630 770 -630 {
lab=PD}
N 570 -680 590 -680 {
lab=#net1}
N 770 -680 860 -680 {
lab=PU}
N 770 -630 860 -630 {
lab=PD}
N 1050 -650 1200 -650 {
lab=#net3}
N 1050 -630 1200 -630 {
lab=#net4}
N 590 -630 590 -500 {
lab=#net2}
N 600 -370 890 -370 {
lab=Vdiv}
N 1980 -660 2040 -660 {
lab=VCO_op}
N 1920 -660 1980 -660 {
lab=VCO_op}
N 1870 -660 1920 -660 {
lab=VCO_op}
N 1690 -670 1730 -670 {
lab=VDD_VCO}
N 1870 -640 1900 -640 {
lab=VCO_op_bar}
N 750 -680 770 -680 {
lab=PU}
N 790 -910 790 -890 {
lab=VSS}
N 580 -1010 580 -1000 {
lab=VSS}
N 790 -1020 810 -1020 {
lab=Vref}
N 610 -1220 610 -1210 {
lab=VSS}
N 610 -1300 610 -1280 {
lab=VDD}
N 690 -1300 690 -1280 {
lab=VSS}
N 690 -1220 690 -1200 {
lab=GND}
N 1690 -690 1690 -670 {
lab=VDD_VCO}
N 890 -370 1060 -370 {
lab=Vdiv}
N 1020 -350 1060 -350 {
lab=VDD}
N 1020 -330 1060 -330 {
lab=VSS}
N 1360 -350 1390 -350 {
lab=F2}
N 1360 -330 1390 -330 {
lab=RST_DIV}
N 570 -780 570 -770 {
lab=VSS}
N 570 -860 570 -840 {
lab=RST_DIV}
N 1550 -640 1560 -640 {
lab=vcntl}
N 790 -1020 790 -970 {
lab=Vref}
N 1730 -670 1740 -670 {
lab=VDD_VCO}
N 1560 -640 1720 -640 {
lab=vcntl}
N 1360 -410 1380 -410 {
lab=#net5}
N 1380 -410 1390 -410 {
lab=#net5}
N 1360 -390 1390 -390 {
lab=F0}
N 1360 -370 1390 -370 {
lab=F1}
N 580 -1080 580 -1070 {
lab=VDD_VCO}
N 580 -1080 600 -1080 {
lab=VDD_VCO}
N 930 -1200 930 -1190 {
lab=VSS}
N 930 -1280 930 -1260 {
lab=F1}
N 790 -1220 790 -1210 {
lab=VSS}
N 790 -1300 790 -1280 {
lab=F0}
N 1030 -1200 1030 -1190 {
lab=VSS}
N 1030 -1280 1030 -1260 {
lab=F2}
N 2260 -820 2290 -820 {
lab=RST_DIV}
N 2260 -870 2260 -820 {
lab=RST_DIV}
N 2230 -760 2290 -760 {
lab=VCO_op}
N 2250 -800 2290 -800 {
lab=OPA1}
N 2250 -870 2250 -800 {
lab=OPA1}
N 2240 -780 2290 -780 {
lab=OPA0}
N 2240 -870 2240 -780 {
lab=OPA0}
N 2590 -820 2610 -820 {
lab=VSS}
N 2590 -800 2610 -800 {
lab=VDD}
N 2590 -780 2630 -780 {
lab=Output1}
N 2250 -890 2250 -870 {
lab=OPA1}
N 2280 -530 2310 -530 {
lab=VCO_op}
N 2280 -530 2280 -480 {
lab=VCO_op}
N 2250 -590 2310 -590 {
lab=RST_DIV}
N 2270 -550 2310 -550 {
lab=OPB0}
N 2270 -550 2270 -480 {
lab=OPB0}
N 2260 -570 2310 -570 {
lab=OPB1}
N 2260 -570 2260 -480 {
lab=OPB1}
N 2610 -590 2630 -590 {
lab=VSS}
N 2610 -550 2630 -550 {
lab=Output2}
N 2610 -570 2650 -570 {
lab=VDD}
N 2270 -480 2270 -460 {
lab=OPB0}
N 1150 -1190 1150 -1180 {
lab=VSS}
N 1150 -1270 1150 -1250 {
lab=OPA0}
N 1250 -1190 1250 -1180 {
lab=VSS}
N 1250 -1270 1250 -1250 {
lab=OPA1}
N 1330 -1190 1330 -1180 {
lab=VSS}
N 1330 -1270 1330 -1250 {
lab=OPB0}
N 1430 -1190 1430 -1180 {
lab=VSS}
N 1430 -1270 1430 -1250 {
lab=OPB1}
N 1310 -740 1310 -720 {
lab=VDD}
N 1310 -560 1310 -540 {
lab=VSS}
N 1200 -650 1220 -650 {
lab=#net3}
N 1200 -630 1220 -630 {
lab=#net4}
N 1460 -510 1460 -490 {
lab=VSS}
N 1280 -740 1280 -720 {
lab=IPD+}
N 1280 -560 1280 -540 {
lab=IPD_}
N 1390 -640 1550 -640 {
lab=vcntl}
N 950 -1030 950 -1010 {
lab=VSS}
N 1020 -1030 1020 -1010 {
lab=IPD+}
N 950 -1110 950 -1090 {
lab=IPD_}
N 1020 -1110 1020 -1090 {
lab=VDD}
N 490 -680 520 -680 {
lab=#net1}
N 1480 -640 1480 -620 {
lab=vcntl}
N 1430 -620 1450 -620 {
lab=VDD}
N 1720 -640 1740 -640 {
lab=vcntl}
N 520 -680 570 -680 {
lab=#net1}
N 60 -700 90 -700 {
lab=Vref}
N 400 -680 470 -680 {
lab=#net1}
N 470 -680 490 -680 {
lab=#net1}
N 90 -700 100 -700 {
lab=Vref}
N 860 -630 860 -540 {
lab=PD}
N 860 -540 900 -540 {
lab=PD}
N 890 -560 900 -560 {
lab=PD_test}
N 890 -580 890 -560 {
lab=PD_test}
N 860 -740 860 -680 {
lab=PU}
N 860 -740 890 -740 {
lab=PU}
N 940 -700 940 -680 {
lab=VSS}
N 930 -620 930 -610 {
lab=S1}
N 950 -620 950 -600 {
lab=VDD}
N 970 -750 1050 -750 {
lab=#net3}
N 1050 -750 1050 -680 {
lab=#net3}
N 1050 -630 1050 -550 {
lab=#net4}
N 980 -550 1050 -550 {
lab=#net4}
N 1050 -680 1050 -650 {
lab=#net3}
N 920 -830 920 -810 {
lab=S1}
N 940 -830 940 -800 {
lab=VDD}
N 860 -760 890 -760 {
lab=PU_test}
N 950 -500 950 -480 {
lab=VSS}
N 640 -470 660 -470 {
lab=VSS}
N 520 -470 540 -470 {
lab=VDD}
N 510 -450 530 -450 {
lab=S1}
N 600 -420 600 -370 {
lab=Vdiv}
N 580 -420 580 -390 {
lab=Vdiv_test}
N 1560 -1190 1560 -1180 {
lab=VSS}
N 1560 -1270 1560 -1250 {
lab=S1}
N 2070 -630 2070 -610 {
lab=Vo_test}
N 2050 -310 2050 -300 {
lab=#net5}
N 1540 -300 2050 -300 {
lab=#net5}
N 1540 -410 1540 -300 {
lab=#net5}
N 1390 -410 1540 -410 {
lab=#net5}
N 1970 -460 2000 -460 {
lab=#net6}
N 2100 -460 2130 -460 {
lab=#net7}
N 2050 -660 2050 -610 {
lab=VCO_op}
N 2040 -660 2050 -660 {
lab=VCO_op}
N 2010 -610 2030 -610 {
lab=S1}
C {devices/lab_pin.sym} 80 -660 0 0 {name=p139 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 80 -680 0 0 {name=p140 sig_type=std_logic lab=P0}
C {devices/lab_pin.sym} 60 -700 0 0 {name=p141 sig_type=std_logic lab=Vref
}
C {devices/lab_pin.sym} 420 -640 2 0 {name=p142 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 420 -660 2 0 {name=p143 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 80 -640 0 0 {name=p144 sig_type=std_logic lab=RST_DIV}
C {devices/vsource.sym} 410 -1240 0 0 {name=V1 value=0}
C {devices/lab_wire.sym} 410 -1200 0 0 {name=p1 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 410 -1290 0 0 {name=p2 sig_type=std_logic lab=P1}
C {devices/vsource.sym} 510 -1240 0 0 {name=V2 value=0}
C {devices/lab_wire.sym} 510 -1200 0 0 {name=p3 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 510 -1290 0 0 {name=p4 sig_type=std_logic lab=P0}
C {PFD.sym} 390 -470 0 0 {name=x3}
C {devices/lab_pin.sym} 680 -740 2 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 680 -570 2 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 760 -370 3 0 {name=p28 sig_type=std_logic lab=Vdiv
}
C {devices/lab_pin.sym} 2040 -660 2 0 {name=p36 sig_type=std_logic lab=VCO_op
}
C {devices/vsource.sym} 790 -940 0 0 {name=VCNTL value="pulse(3.3 0 0 100p 100p 250n 500n)"}
C {devices/vsource.sym} 580 -1040 0 0 {name=V3 value=" PWL( 0 0 100n 0 100.001n 3.3)"}
C {devices/code_shown.sym} 2010 -1030 0 1 {name=NGSPICE1 only_toplevel=true
value="
.control
save all
tran 10n 50u 
plot v(VCO_op) v(VCO_op_bar)+4
**write pll_4.raw
.endc
"}
C {devices/vsource.sym} 610 -1250 0 0 {name=V4 value=3.3}
C {devices/vsource.sym} 690 -1250 0 0 {name=V5 value=0}
C {devices/lab_wire.sym} 690 -1300 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 610 -1210 0 0 {name=p8 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 610 -1300 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 690 -1200 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 1690 -690 0 0 {name=p12 sig_type=std_logic lab=VDD_VCO}
C {devices/lab_pin.sym} 1900 -640 2 0 {name=p13 sig_type=std_logic lab=VCO_op_bar
}
C {devices/lab_pin.sym} 1020 -350 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1020 -330 3 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 600 -1080 2 0 {name=p16 sig_type=std_logic lab=VDD_VCO}
C {devices/lab_pin.sym} 800 -1020 2 0 {name=p17 sig_type=std_logic lab=Vref
}
C {devices/lab_wire.sym} 570 -770 0 0 {name=p18 sig_type=std_logic lab=VSS
}
C {devices/vsource.sym} 570 -810 0 0 {name=V6 value=" PWL( 0 0 10n 0 10.001n 3)"}
C {devices/lab_pin.sym} 1480 -640 1 0 {name=p19 sig_type=std_logic lab=vcntl
}
C {devices/lab_pin.sym} 810 -680 1 0 {name=p20 sig_type=std_logic lab=PU}
C {devices/lab_pin.sym} 810 -630 1 0 {name=p21 sig_type=std_logic lab=PD}
C {Feedback_Divider.sym} 1210 -370 2 0 {name=x2}
C {devices/lab_pin.sym} 1390 -390 2 0 {name=p22 sig_type=std_logic lab=F0}
C {devices/lab_pin.sym} 1390 -370 2 0 {name=p23 sig_type=std_logic lab=F1}
C {devices/lab_pin.sym} 1390 -350 2 0 {name=p24 sig_type=std_logic lab=F2}
C {devices/vsource.sym} 930 -1230 0 0 {name=V7 value=3.3}
C {devices/lab_wire.sym} 930 -1190 0 0 {name=p26 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 930 -1280 0 0 {name=p27 sig_type=std_logic lab=F1}
C {devices/vsource.sym} 790 -1250 0 0 {name=V8 value=3.3}
C {devices/lab_wire.sym} 790 -1210 0 0 {name=p25 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 790 -1300 0 0 {name=p29 sig_type=std_logic lab=F0}
C {devices/vsource.sym} 1030 -1230 0 0 {name=V9 value=3.3}
C {devices/lab_wire.sym} 1030 -1190 0 0 {name=p30 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1030 -1280 0 0 {name=p31 sig_type=std_logic lab=F2}
C {devices/lab_pin.sym} 2610 -800 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2610 -820 2 0 {name=p33 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -860 0 0 {name=p82 sig_type=std_logic lab=OPA0}
C {devices/lab_wire.sym} 2250 -890 0 0 {name=p83 sig_type=std_logic lab=OPA1}
C {devices/lab_pin.sym} 2260 -870 2 0 {name=p34 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 2620 -780 2 0 {name=p84 sig_type=std_logic lab=Output1}
C {devices/lab_pin.sym} 2640 -570 0 1 {name=p85 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2620 -590 0 1 {name=p86 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2260 -490 2 1 {name=p87 sig_type=std_logic lab=OPB1}
C {devices/lab_wire.sym} 2270 -460 2 1 {name=p88 sig_type=std_logic lab=OPB0}
C {devices/lab_pin.sym} 2630 -550 0 1 {name=p90 sig_type=std_logic lab=Output2}
C {Output_Divider.sym} 2460 -560 0 0 {name=x5}
C {devices/lab_pin.sym} 2290 -590 1 0 {name=p35 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 2280 -480 2 0 {name=p37 sig_type=std_logic lab=VCO_op
}
C {devices/lab_pin.sym} 2240 -760 2 1 {name=p40 sig_type=std_logic lab=VCO_op
}
C {devices/vsource.sym} 1150 -1220 0 0 {name=V10 value=3.3}
C {devices/lab_wire.sym} 1150 -1180 0 0 {name=p41 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1150 -1270 0 0 {name=p42 sig_type=std_logic lab=OPA0}
C {devices/vsource.sym} 1250 -1220 0 0 {name=V11 value=3.3}
C {devices/lab_wire.sym} 1250 -1180 0 0 {name=p43 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1250 -1270 0 0 {name=p44 sig_type=std_logic lab=OPA1}
C {devices/vsource.sym} 1330 -1220 0 0 {name=V12 value=3.3}
C {devices/lab_wire.sym} 1330 -1180 0 0 {name=p45 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1330 -1270 0 0 {name=p46 sig_type=std_logic lab=OPB0
}
C {devices/vsource.sym} 1430 -1220 0 0 {name=V13 value=0}
C {devices/lab_wire.sym} 1430 -1180 0 0 {name=p47 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1430 -1270 0 0 {name=p48 sig_type=std_logic lab=OPB1}
C {devices/lab_pin.sym} 570 -850 2 0 {name=p38 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 1380 -330 2 0 {name=p39 sig_type=std_logic lab=RST_DIV}
C {devices/lab_wire.sym} 1310 -540 2 0 {name=p49 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1310 -740 2 0 {name=p50 sig_type=std_logic lab=VDD}
C {CP.sym} 730 -440 0 0 {name=x6}
C {LF.sym} 1320 -460 0 0 {name=x7}
C {devices/lab_wire.sym} 1460 -490 2 0 {name=p51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1280 -730 0 0 {name=p52 sig_type=std_logic lab=IPD+}
C {devices/lab_wire.sym} 1280 -540 0 0 {name=p53 sig_type=std_logic lab=IPD_}
C {devices/isource.sym} 950 -1060 0 0 {name=I0 value=20u}
C {devices/isource.sym} 1020 -1060 0 0 {name=I1 value=20u}
C {devices/lab_wire.sym} 950 -1110 0 0 {name=p54 sig_type=std_logic lab=IPD_}
C {devices/lab_wire.sym} 1020 -1010 2 0 {name=p55 sig_type=std_logic lab=IPD+}
C {devices/lab_wire.sym} 950 -1010 2 0 {name=p56 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1020 -1110 2 0 {name=p57 sig_type=std_logic lab=VDD}
C {Output_Divider.sym} 2440 -790 0 0 {name=x4}
C {devices/code_shown.sym} 1110 -1010 0 0 {name=MODELS2 only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
"}
C {devices/lab_pin.sym} 1440 -620 0 0 {name=p59 sig_type=std_logic lab=VDD}
C {VCO_smb_old.sym} 1890 -650 0 0 {name=x8}
C {Prescalar_Divider.sym} 250 -670 2 1 {name=x1}
C {devices/lab_wire.sym} 580 -1000 2 0 {name=p5 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 790 -890 2 0 {name=p6 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 360 -680 0 0 {name=p58 sig_type=std_logic lab=Vref
}
C {2x1_mux.sym} 690 -630 0 0 {name=x9}
C {2x1_mux.sym} 700 -430 0 0 {name=x10}
C {devices/lab_pin.sym} 860 -760 0 0 {name=p60 sig_type=std_logic lab=PU_test
}
C {devices/lab_pin.sym} 890 -580 1 0 {name=p61 sig_type=std_logic lab=PD_test
}
C {devices/lab_pin.sym} 940 -820 2 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 950 -620 2 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 950 -480 2 0 {name=p64 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 940 -680 2 0 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 920 -820 1 0 {name=p106 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 930 -620 1 0 {name=p66 sig_type=std_logic lab=S1}
C {2x1_mux.sym} 710 -220 3 0 {name=x11}
C {devices/lab_wire.sym} 660 -470 2 0 {name=p67 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 520 -470 2 1 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 510 -450 0 0 {name=p69 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 580 -390 0 0 {name=p70 sig_type=std_logic lab=Vdiv_test
}
C {devices/vsource.sym} 1560 -1220 0 0 {name=V14 value=3.3}
C {devices/lab_wire.sym} 1560 -1180 0 0 {name=p71 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1560 -1270 0 0 {name=p72 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 2070 -630 2 0 {name=p76 sig_type=std_logic lab=Vo_test
}
C {A_MUX.sym} 2050 -460 1 0 {name=x12}
C {devices/lab_pin.sym} 2010 -610 0 0 {name=p73 sig_type=std_logic lab=S1}
