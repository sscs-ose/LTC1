v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 160 -560 180 -560 {
lab=P0}
N 160 -540 180 -540 {
lab=P1}
N 160 -520 180 -520 {
lab=RST_DIV}
N 480 -520 500 -520 {
lab=VSS}
N 480 -540 500 -540 {
lab=VDD}
N 490 -1090 490 -1080 {
lab=VSS}
N 490 -1170 490 -1150 {
lab=P1}
N 590 -1090 590 -1080 {
lab=VSS}
N 590 -1170 590 -1150 {
lab=P0}
N 760 -620 760 -600 {
lab=VDD}
N 760 -470 760 -450 {
lab=VSS}
N 670 -560 690 -560 {
lab=#net1}
N 670 -510 690 -510 {
lab=#net2}
N 830 -510 850 -510 {
lab=PD}
N 650 -560 670 -560 {
lab=#net1}
N 850 -560 940 -560 {
lab=PU}
N 850 -510 940 -510 {
lab=PD}
N 1130 -530 1280 -530 {
lab=#net3}
N 1130 -510 1280 -510 {
lab=#net4}
N 670 -510 670 -380 {
lab=#net2}
N 880 -210 1170 -210 {
lab=Vdiv}
N 2360 -540 2420 -540 {
lab=VCO_op}
N 2300 -540 2360 -540 {
lab=VCO_op}
N 2250 -540 2300 -540 {
lab=VCO_op}
N 2070 -550 2110 -550 {
lab=VDD_VCO}
N 2250 -520 2280 -520 {
lab=VCO_op_bar}
N 830 -560 850 -560 {
lab=PU}
N 860 -910 860 -890 {
lab=VSS}
N 660 -930 660 -920 {
lab=VSS}
N 860 -1000 880 -1000 {
lab=Vref}
N 690 -1100 690 -1090 {
lab=VSS}
N 690 -1180 690 -1160 {
lab=VDD}
N 770 -1180 770 -1160 {
lab=VSS}
N 770 -1100 770 -1080 {
lab=GND}
N 2070 -570 2070 -550 {
lab=VDD_VCO}
N 1130 -250 1170 -250 {
lab=VSS}
N 1130 -230 1170 -230 {
lab=VDD}
N 1470 -230 1500 -230 {
lab=F2}
N 1470 -250 1500 -250 {
lab=RST_DIV}
N 450 -930 450 -920 {
lab=VSS}
N 450 -1010 450 -990 {
lab=RST_DIV}
N 1630 -520 1640 -520 {
lab=LP_op_test}
N 2110 -550 2120 -550 {
lab=VDD_VCO}
N 1470 -190 1500 -190 {
lab=F0}
N 1470 -210 1500 -210 {
lab=F1}
N 660 -1000 660 -990 {
lab=VDD_VCO}
N 660 -1000 680 -1000 {
lab=VDD_VCO}
N 1010 -1080 1010 -1070 {
lab=VSS}
N 1010 -1160 1010 -1140 {
lab=F1}
N 870 -1100 870 -1090 {
lab=VSS}
N 870 -1180 870 -1160 {
lab=F0}
N 1110 -1080 1110 -1070 {
lab=VSS}
N 1110 -1160 1110 -1140 {
lab=F2}
N 2800 -670 2830 -670 {
lab=RST_DIV}
N 2800 -720 2800 -670 {
lab=RST_DIV}
N 2770 -610 2830 -610 {
lab=VCO_op}
N 2790 -650 2830 -650 {
lab=OPA1}
N 2790 -720 2790 -650 {
lab=OPA1}
N 2780 -630 2830 -630 {
lab=OPA0}
N 2780 -720 2780 -630 {
lab=OPA0}
N 3130 -670 3150 -670 {
lab=VSS}
N 3130 -650 3150 -650 {
lab=VDD}
N 3130 -630 3170 -630 {
lab=Output1}
N 2790 -740 2790 -720 {
lab=OPA1}
N 2820 -380 2850 -380 {
lab=VCO_op}
N 2820 -380 2820 -330 {
lab=VCO_op}
N 2790 -440 2850 -440 {
lab=RST_DIV}
N 2810 -400 2850 -400 {
lab=OPB0}
N 2810 -400 2810 -330 {
lab=OPB0}
N 2800 -420 2850 -420 {
lab=OPB1}
N 2800 -420 2800 -330 {
lab=OPB1}
N 3150 -440 3170 -440 {
lab=VSS}
N 3150 -400 3170 -400 {
lab=Output2}
N 3150 -420 3190 -420 {
lab=VDD}
N 2810 -330 2810 -310 {
lab=OPB0}
N 1230 -1070 1230 -1060 {
lab=VSS}
N 1230 -1150 1230 -1130 {
lab=OPA0}
N 1330 -1070 1330 -1060 {
lab=VSS}
N 1330 -1150 1330 -1130 {
lab=OPA1}
N 1410 -1070 1410 -1060 {
lab=VSS}
N 1410 -1150 1410 -1130 {
lab=OPB0}
N 1510 -1070 1510 -1060 {
lab=VSS}
N 1510 -1150 1510 -1130 {
lab=OPB1}
N 1390 -620 1390 -600 {
lab=VDD}
N 1390 -440 1390 -420 {
lab=VSS}
N 1280 -530 1300 -530 {
lab=#net3}
N 1280 -510 1300 -510 {
lab=#net4}
N 1540 -390 1540 -370 {
lab=VSS}
N 1360 -620 1360 -600 {
lab=IPD+}
N 1360 -440 1360 -420 {
lab=IPD_}
N 1470 -520 1630 -520 {
lab=LP_op_test}
N 1030 -910 1030 -890 {
lab=VSS}
N 1100 -910 1100 -890 {
lab=IPD+}
N 1030 -990 1030 -970 {
lab=IPD_}
N 1100 -990 1100 -970 {
lab=VDD}
N 570 -560 600 -560 {
lab=#net1}
N 1560 -520 1560 -500 {
lab=LP_op_test}
N 1510 -500 1530 -500 {
lab=VDD}
N 2100 -520 2120 -520 {
lab=#net5}
N 600 -560 650 -560 {
lab=#net1}
N 140 -580 170 -580 {
lab=Vref}
N 480 -560 550 -560 {
lab=#net1}
N 550 -560 570 -560 {
lab=#net1}
N 170 -580 180 -580 {
lab=Vref}
N 940 -510 940 -420 {
lab=PD}
N 940 -420 980 -420 {
lab=PD}
N 970 -440 980 -440 {
lab=PD_test}
N 970 -460 970 -440 {
lab=PD_test}
N 940 -620 940 -560 {
lab=PU}
N 940 -620 970 -620 {
lab=PU}
N 1020 -580 1020 -560 {
lab=VSS}
N 1010 -500 1010 -490 {
lab=S1}
N 1030 -500 1030 -480 {
lab=VDD}
N 1050 -630 1130 -630 {
lab=#net3}
N 1130 -630 1130 -560 {
lab=#net3}
N 1130 -510 1130 -430 {
lab=#net4}
N 1060 -430 1130 -430 {
lab=#net4}
N 1130 -560 1130 -530 {
lab=#net3}
N 1000 -710 1000 -690 {
lab=S1}
N 1020 -710 1020 -680 {
lab=VDD}
N 940 -640 970 -640 {
lab=PU_test}
N 1030 -380 1030 -360 {
lab=VSS}
N 720 -350 740 -350 {
lab=VSS}
N 600 -350 620 -350 {
lab=VDD}
N 590 -330 610 -330 {
lab=S1}
N 680 -300 680 -250 {
lab=Vdiv}
N 660 -300 660 -270 {
lab=Vdiv_test}
N 1640 -1070 1640 -1060 {
lab=VSS}
N 1640 -1150 1640 -1130 {
lab=S1}
N 1970 -520 2100 -520 {
lab=#net5}
N 1820 -590 1820 -570 {
lab=VDD}
N 1820 -470 1820 -440 {
lab=VSS}
N 1640 -520 1670 -520 {
lab=LP_op_test}
N 1650 -540 1670 -540 {
lab=vcntl_test}
N 1650 -580 1650 -540 {
lab=vcntl_test}
N 1650 -500 1670 -500 {
lab=S1}
N 1650 -500 1650 -470 {
lab=S1}
N 2420 -540 2480 -540 {
lab=VCO_op}
N 2510 -510 2510 -490 {
lab=Vo_test}
N 2490 -190 2490 -180 {
lab=#net6}
N 2410 -340 2440 -340 {
lab=VSS}
N 2540 -340 2570 -340 {
lab=VDD}
N 2490 -540 2490 -490 {
lab=VCO_op}
N 2480 -540 2490 -540 {
lab=VCO_op}
N 2450 -490 2470 -490 {
lab=S1}
N 2490 -180 2490 -170 {
lab=#net6}
N 2140 -170 2490 -170 {
lab=#net6}
N 680 -210 880 -210 {
lab=Vdiv}
N 680 -250 680 -210 {
lab=Vdiv}
N 1470 -170 2140 -170 {
lab=#net6}
N 860 -1000 860 -970 {
lab=Vref}
C {devices/lab_pin.sym} 160 -540 0 0 {name=p139 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 160 -560 0 0 {name=p140 sig_type=std_logic lab=P0}
C {devices/lab_pin.sym} 140 -580 0 0 {name=p141 sig_type=std_logic lab=Vref
}
C {devices/lab_pin.sym} 500 -520 2 0 {name=p142 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 500 -540 2 0 {name=p143 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 160 -520 0 0 {name=p144 sig_type=std_logic lab=RST_DIV}
C {devices/vsource.sym} 490 -1120 0 0 {name=V1 value=0}
C {devices/lab_wire.sym} 490 -1080 0 0 {name=p1 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 490 -1170 0 0 {name=p2 sig_type=std_logic lab=P1}
C {devices/vsource.sym} 590 -1120 0 0 {name=V2 value=0}
C {devices/lab_wire.sym} 590 -1080 0 0 {name=p3 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 590 -1170 0 0 {name=p4 sig_type=std_logic lab=P0}
C {PFD.sym} 470 -350 0 0 {name=x3}
C {devices/lab_pin.sym} 760 -620 2 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 760 -450 2 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 900 -210 1 0 {name=p28 sig_type=std_logic lab=Vdiv
}
C {devices/vsource.sym} 860 -940 0 0 {name=VCNTL value="pulse(3.3 0 0 100p 100p 250n 500n)"}
C {devices/vsource.sym} 660 -960 0 0 {name=V3 value=" PWL( 0 0 100n 0 100.001n 3.3)"}
C {devices/code_shown.sym} 2090 -910 0 1 {name=NGSPICE1 only_toplevel=true
value="
.control
save all
tran 10n 50u 
plot v(VCO_op) v(VCO_op_bar)+4
**write pll_4.raw
.endc
"}
C {devices/vsource.sym} 690 -1130 0 0 {name=V4 value=3.3}
C {devices/vsource.sym} 770 -1130 0 0 {name=V5 value=0}
C {devices/lab_wire.sym} 770 -1180 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 690 -1090 0 0 {name=p8 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 690 -1180 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 770 -1080 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 2070 -570 0 0 {name=p12 sig_type=std_logic lab=VDD_VCO}
C {devices/lab_pin.sym} 2280 -520 2 0 {name=p13 sig_type=std_logic lab=VCO_op_bar
}
C {devices/lab_pin.sym} 1130 -230 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1130 -250 1 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 680 -1000 2 0 {name=p16 sig_type=std_logic lab=VDD_VCO}
C {devices/lab_pin.sym} 870 -1000 2 0 {name=p17 sig_type=std_logic lab=Vref
}
C {devices/lab_wire.sym} 450 -920 0 0 {name=p18 sig_type=std_logic lab=VSS
}
C {devices/vsource.sym} 450 -960 0 0 {name=V6 value=" PWL( 0 0 10n 0 10.001n 3)"}
C {devices/lab_pin.sym} 1520 -520 1 0 {name=p19 sig_type=std_logic lab=LP_op_test
}
C {devices/lab_pin.sym} 890 -560 1 0 {name=p20 sig_type=std_logic lab=PU}
C {devices/lab_pin.sym} 890 -510 1 0 {name=p21 sig_type=std_logic lab=PD}
C {Feedback_Divider.sym} 1320 -210 0 1 {name=x2}
C {devices/lab_pin.sym} 1500 -190 2 0 {name=p22 sig_type=std_logic lab=F0}
C {devices/lab_pin.sym} 1500 -210 2 0 {name=p23 sig_type=std_logic lab=F1}
C {devices/lab_pin.sym} 1500 -230 2 0 {name=p24 sig_type=std_logic lab=F2}
C {devices/vsource.sym} 1010 -1110 0 0 {name=V7 value=3.3}
C {devices/lab_wire.sym} 1010 -1070 0 0 {name=p26 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1010 -1160 0 0 {name=p27 sig_type=std_logic lab=F1}
C {devices/vsource.sym} 870 -1130 0 0 {name=V8 value=3.3}
C {devices/lab_wire.sym} 870 -1090 0 0 {name=p25 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 870 -1180 0 0 {name=p29 sig_type=std_logic lab=F0}
C {devices/vsource.sym} 1110 -1110 0 0 {name=V9 value=3.3}
C {devices/lab_wire.sym} 1110 -1070 0 0 {name=p30 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1110 -1160 0 0 {name=p31 sig_type=std_logic lab=F2}
C {devices/lab_pin.sym} 3150 -650 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -670 2 0 {name=p33 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2780 -710 0 0 {name=p82 sig_type=std_logic lab=OPA0}
C {devices/lab_wire.sym} 2790 -740 0 0 {name=p83 sig_type=std_logic lab=OPA1}
C {devices/lab_pin.sym} 2800 -720 2 0 {name=p34 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 3160 -630 2 0 {name=p84 sig_type=std_logic lab=Output1}
C {devices/lab_pin.sym} 3180 -420 0 1 {name=p85 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3160 -440 0 1 {name=p86 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2800 -340 2 1 {name=p87 sig_type=std_logic lab=OPB1}
C {devices/lab_wire.sym} 2810 -310 2 1 {name=p88 sig_type=std_logic lab=OPB0}
C {devices/lab_pin.sym} 3170 -400 0 1 {name=p90 sig_type=std_logic lab=Output2}
C {Output_Divider.sym} 3000 -410 0 0 {name=x5}
C {devices/lab_pin.sym} 2830 -440 1 0 {name=p35 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 2820 -330 2 0 {name=p37 sig_type=std_logic lab=VCO_op
}
C {devices/lab_pin.sym} 2780 -610 2 1 {name=p40 sig_type=std_logic lab=VCO_op
}
C {devices/vsource.sym} 1230 -1100 0 0 {name=V10 value=3.3}
C {devices/lab_wire.sym} 1230 -1060 0 0 {name=p41 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1230 -1150 0 0 {name=p42 sig_type=std_logic lab=OPA0}
C {devices/vsource.sym} 1330 -1100 0 0 {name=V11 value=3.3}
C {devices/lab_wire.sym} 1330 -1060 0 0 {name=p43 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1330 -1150 0 0 {name=p44 sig_type=std_logic lab=OPA1}
C {devices/vsource.sym} 1410 -1100 0 0 {name=V12 value=3.3}
C {devices/lab_wire.sym} 1410 -1060 0 0 {name=p45 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1410 -1150 0 0 {name=p46 sig_type=std_logic lab=OPB0
}
C {devices/vsource.sym} 1510 -1100 0 0 {name=V13 value=0}
C {devices/lab_wire.sym} 1510 -1060 0 0 {name=p47 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1510 -1150 0 0 {name=p48 sig_type=std_logic lab=OPB1}
C {devices/lab_pin.sym} 450 -1000 2 0 {name=p38 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 1490 -250 2 0 {name=p39 sig_type=std_logic lab=RST_DIV}
C {devices/lab_wire.sym} 1390 -420 2 0 {name=p49 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1390 -620 2 0 {name=p50 sig_type=std_logic lab=VDD}
C {CP.sym} 810 -320 0 0 {name=x6}
C {LF.sym} 1400 -340 0 0 {name=x7}
C {devices/lab_wire.sym} 1540 -370 2 0 {name=p51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1360 -610 0 0 {name=p52 sig_type=std_logic lab=IPD+}
C {devices/lab_wire.sym} 1360 -420 0 0 {name=p53 sig_type=std_logic lab=IPD_}
C {devices/isource.sym} 1030 -940 0 0 {name=I0 value=20u}
C {devices/isource.sym} 1100 -940 0 0 {name=I1 value=20u}
C {devices/lab_wire.sym} 1030 -990 0 0 {name=p54 sig_type=std_logic lab=IPD_}
C {devices/lab_wire.sym} 1100 -890 2 0 {name=p55 sig_type=std_logic lab=IPD+}
C {devices/lab_wire.sym} 1030 -890 2 0 {name=p56 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1100 -990 2 0 {name=p57 sig_type=std_logic lab=VDD}
C {Output_Divider.sym} 2980 -640 0 0 {name=x4}
C {devices/code_shown.sym} 1190 -890 0 0 {name=MODELS2 only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
"}
C {devices/lab_pin.sym} 1520 -500 0 0 {name=p59 sig_type=std_logic lab=VDD}
C {VCO_smb_old.sym} 2270 -530 0 0 {name=x8}
C {Prescalar_Divider.sym} 330 -550 2 1 {name=x1}
C {devices/lab_wire.sym} 660 -920 2 0 {name=p5 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 860 -890 2 0 {name=p6 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 440 -560 0 0 {name=p58 sig_type=std_logic lab=Vref
}
C {2x1_mux.sym} 770 -510 0 0 {name=x9}
C {2x1_mux.sym} 780 -310 0 0 {name=x10}
C {devices/lab_pin.sym} 940 -640 0 0 {name=p60 sig_type=std_logic lab=PU_test
}
C {devices/lab_pin.sym} 970 -460 1 0 {name=p61 sig_type=std_logic lab=PD_test
}
C {devices/lab_pin.sym} 1020 -700 2 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1030 -500 2 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1030 -360 2 0 {name=p64 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1020 -560 2 0 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1000 -700 1 0 {name=p106 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 1010 -500 1 0 {name=p66 sig_type=std_logic lab=S1}
C {2x1_mux.sym} 790 -100 3 0 {name=x11}
C {devices/lab_wire.sym} 740 -350 2 0 {name=p67 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 600 -350 2 1 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 590 -330 0 0 {name=p69 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 660 -270 0 0 {name=p70 sig_type=std_logic lab=Vdiv_test
}
C {devices/vsource.sym} 1640 -1100 0 0 {name=V14 value=3.3}
C {devices/lab_wire.sym} 1640 -1060 0 0 {name=p71 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1640 -1150 0 0 {name=p72 sig_type=std_logic lab=S1}
C {A_MUX.sym} 1820 -520 0 0 {name=x12}
C {devices/lab_pin.sym} 1820 -580 2 0 {name=p73 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -440 2 0 {name=p74 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -480 2 0 {name=p75 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 1650 -580 0 0 {name=p76 sig_type=std_logic lab=vcntl_test
}
C {devices/lab_pin.sym} 2480 -540 2 0 {name=p77 sig_type=std_logic lab=VCO_op
}
C {devices/lab_pin.sym} 2510 -510 2 0 {name=p78 sig_type=std_logic lab=Vo_test
}
C {A_MUX.sym} 2490 -340 1 0 {name=x13}
C {devices/lab_pin.sym} 2450 -490 0 0 {name=p79 sig_type=std_logic lab=S1}
C {devices/lab_wire.sym} 2410 -340 0 0 {name=p36 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2570 -340 2 0 {name=p80 sig_type=std_logic lab=VDD}
