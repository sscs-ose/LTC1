v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 180 -460 200 -460 {
lab=P0}
N 180 -440 200 -440 {
lab=P1}
N 180 -420 200 -420 {
lab=RST_DIV}
N 500 -420 520 -420 {
lab=VSS}
N 500 -440 520 -440 {
lab=VDD}
N 510 -990 510 -980 {
lab=VSS}
N 510 -1070 510 -1050 {
lab=P1}
N 610 -990 610 -980 {
lab=VSS}
N 610 -1070 610 -1050 {
lab=P0}
N 780 -520 780 -500 {
lab=VDD}
N 780 -370 780 -350 {
lab=VSS}
N 690 -460 710 -460 {
lab=#net1}
N 690 -410 710 -410 {
lab=#net2}
N 850 -410 870 -410 {
lab=PD}
N 670 -460 690 -460 {
lab=#net1}
N 870 -460 960 -460 {
lab=PU}
N 870 -410 960 -410 {
lab=PD}
N 1150 -430 1300 -430 {
lab=#net3}
N 1150 -410 1300 -410 {
lab=#net4}
N 690 -410 690 -280 {
lab=#net2}
N 700 -150 990 -150 {
lab=Vdiv}
N 2380 -440 2440 -440 {
lab=VCO_op}
N 2320 -440 2380 -440 {
lab=VCO_op}
N 2270 -440 2320 -440 {
lab=VCO_op}
N 2090 -450 2130 -450 {
lab=VDD_VCO}
N 2270 -420 2300 -420 {
lab=VCO_op_bar}
N 850 -460 870 -460 {
lab=PU}
N 890 -690 890 -670 {
lab=VSS}
N 680 -790 680 -780 {
lab=VSS}
N 890 -800 910 -800 {
lab=Vref}
N 710 -1000 710 -990 {
lab=VSS}
N 710 -1080 710 -1060 {
lab=VDD}
N 790 -1080 790 -1060 {
lab=VSS}
N 790 -1000 790 -980 {
lab=GND}
N 2090 -470 2090 -450 {
lab=VDD_VCO}
N 990 -150 1160 -150 {
lab=Vdiv}
N 1120 -130 1160 -130 {
lab=VDD}
N 1120 -110 1160 -110 {
lab=VSS}
N 1460 -130 1490 -130 {
lab=F2}
N 1460 -110 1490 -110 {
lab=RST_DIV}
N 1490 -190 2140 -190 {
lab=VCO_op}
N 670 -560 670 -550 {
lab=VSS}
N 670 -640 670 -620 {
lab=RST_DIV}
N 2440 -440 2440 -420 {
lab=VCO_op}
N 1650 -420 1660 -420 {
lab=vcntl}
N 890 -800 890 -750 {
lab=Vref}
N 2130 -450 2140 -450 {
lab=VDD_VCO}
N 1460 -190 1480 -190 {
lab=VCO_op}
N 1480 -190 1490 -190 {
lab=VCO_op}
N 2440 -420 2440 -190 {
lab=VCO_op}
N 1460 -170 1490 -170 {
lab=F0}
N 1460 -150 1490 -150 {
lab=F1}
N 680 -860 680 -850 {
lab=VDD_VCO}
N 680 -860 700 -860 {
lab=VDD_VCO}
N 1030 -980 1030 -970 {
lab=VSS}
N 1030 -1060 1030 -1040 {
lab=F1}
N 890 -1000 890 -990 {
lab=VSS}
N 890 -1080 890 -1060 {
lab=F0}
N 1130 -980 1130 -970 {
lab=VSS}
N 1130 -1060 1130 -1040 {
lab=F2}
N 2640 -570 2670 -570 {
lab=RST_DIV}
N 2640 -620 2640 -570 {
lab=RST_DIV}
N 2610 -510 2670 -510 {
lab=VCO_op}
N 2630 -550 2670 -550 {
lab=OPA1}
N 2630 -620 2630 -550 {
lab=OPA1}
N 2620 -530 2670 -530 {
lab=OPA0}
N 2620 -620 2620 -530 {
lab=OPA0}
N 2970 -570 2990 -570 {
lab=VSS}
N 2970 -550 2990 -550 {
lab=VDD}
N 2970 -530 3010 -530 {
lab=Output1}
N 2630 -640 2630 -620 {
lab=OPA1}
N 2660 -280 2690 -280 {
lab=VCO_op}
N 2660 -280 2660 -230 {
lab=VCO_op}
N 2630 -340 2690 -340 {
lab=RST_DIV}
N 2650 -300 2690 -300 {
lab=OPB0}
N 2650 -300 2650 -230 {
lab=OPB0}
N 2640 -320 2690 -320 {
lab=OPB1}
N 2640 -320 2640 -230 {
lab=OPB1}
N 2990 -340 3010 -340 {
lab=VSS}
N 2990 -300 3010 -300 {
lab=Output2}
N 2990 -320 3030 -320 {
lab=VDD}
N 2650 -230 2650 -210 {
lab=OPB0}
N 1250 -970 1250 -960 {
lab=VSS}
N 1250 -1050 1250 -1030 {
lab=OPA0}
N 1350 -970 1350 -960 {
lab=VSS}
N 1350 -1050 1350 -1030 {
lab=OPA1}
N 1430 -970 1430 -960 {
lab=VSS}
N 1430 -1050 1430 -1030 {
lab=OPB0}
N 1530 -970 1530 -960 {
lab=VSS}
N 1530 -1050 1530 -1030 {
lab=OPB1}
N 1410 -520 1410 -500 {
lab=VDD}
N 1410 -340 1410 -320 {
lab=VSS}
N 1300 -430 1320 -430 {
lab=#net3}
N 1300 -410 1320 -410 {
lab=#net4}
N 1560 -290 1560 -270 {
lab=VSS}
N 1380 -520 1380 -500 {
lab=IPD+}
N 1380 -340 1380 -320 {
lab=IPD_}
N 1490 -420 1650 -420 {
lab=vcntl}
N 1050 -810 1050 -790 {
lab=VSS}
N 1120 -810 1120 -790 {
lab=IPD+}
N 1050 -890 1050 -870 {
lab=IPD_}
N 1120 -890 1120 -870 {
lab=VDD}
N 590 -460 620 -460 {
lab=#net1}
N 1580 -420 1580 -400 {
lab=vcntl}
N 1530 -400 1550 -400 {
lab=VDD}
N 2120 -420 2140 -420 {
lab=#net5}
N 620 -460 670 -460 {
lab=#net1}
N 160 -480 190 -480 {
lab=Vref}
N 500 -460 570 -460 {
lab=#net1}
N 570 -460 590 -460 {
lab=#net1}
N 190 -480 200 -480 {
lab=Vref}
N 960 -410 960 -320 {
lab=PD}
N 960 -320 1000 -320 {
lab=PD}
N 990 -340 1000 -340 {
lab=PD_test}
N 990 -360 990 -340 {
lab=PD_test}
N 960 -520 960 -460 {
lab=PU}
N 960 -520 990 -520 {
lab=PU}
N 1040 -480 1040 -460 {
lab=VSS}
N 1030 -400 1030 -390 {
lab=S1}
N 1050 -400 1050 -380 {
lab=VDD}
N 1070 -530 1150 -530 {
lab=#net3}
N 1150 -530 1150 -460 {
lab=#net3}
N 1150 -410 1150 -330 {
lab=#net4}
N 1080 -330 1150 -330 {
lab=#net4}
N 1150 -460 1150 -430 {
lab=#net3}
N 1020 -610 1020 -590 {
lab=S1}
N 1040 -610 1040 -580 {
lab=VDD}
N 960 -540 990 -540 {
lab=PU_test}
N 1050 -280 1050 -260 {
lab=VSS}
N 740 -250 760 -250 {
lab=VSS}
N 620 -250 640 -250 {
lab=VDD}
N 610 -230 630 -230 {
lab=S1}
N 700 -200 700 -150 {
lab=Vdiv}
N 680 -200 680 -170 {
lab=Vdiv_test}
N 1660 -970 1660 -960 {
lab=VSS}
N 1660 -1050 1660 -1030 {
lab=S1}
N 2150 -190 2440 -190 {
lab=VCO_op}
N 2140 -190 2150 -190 {
lab=VCO_op}
N 1990 -420 2120 -420 {
lab=#net5}
N 1840 -490 1840 -470 {
lab=VDD}
N 1840 -370 1840 -340 {
lab=VSS}
N 1660 -420 1690 -420 {
lab=vcntl}
N 1670 -440 1690 -440 {
lab=vcntl_test}
N 1670 -480 1670 -440 {
lab=vcntl_test}
N 1670 -400 1690 -400 {
lab=S1}
N 1670 -400 1670 -370 {
lab=S1}
C {devices/lab_pin.sym} 180 -440 0 0 {name=p139 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 180 -460 0 0 {name=p140 sig_type=std_logic lab=P0}
C {devices/lab_pin.sym} 160 -480 0 0 {name=p141 sig_type=std_logic lab=Vref
}
C {devices/lab_pin.sym} 520 -420 2 0 {name=p142 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 520 -440 2 0 {name=p143 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 180 -420 0 0 {name=p144 sig_type=std_logic lab=RST_DIV}
C {devices/vsource.sym} 510 -1020 0 0 {name=V1 value=0}
C {devices/lab_wire.sym} 510 -980 0 0 {name=p1 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 510 -1070 0 0 {name=p2 sig_type=std_logic lab=P1}
C {devices/vsource.sym} 610 -1020 0 0 {name=V2 value=0}
C {devices/lab_wire.sym} 610 -980 0 0 {name=p3 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 610 -1070 0 0 {name=p4 sig_type=std_logic lab=P0}
C {PFD.sym} 490 -250 0 0 {name=x3}
C {devices/lab_pin.sym} 780 -520 2 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 780 -350 2 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 860 -150 3 0 {name=p28 sig_type=std_logic lab=Vdiv
}
C {devices/lab_pin.sym} 2440 -440 2 0 {name=p36 sig_type=std_logic lab=VCO_op
}
C {devices/vsource.sym} 890 -720 0 0 {name=VCNTL value="pulse(3.3 0 0 100p 100p 250n 500n)"}
C {devices/vsource.sym} 680 -820 0 0 {name=V3 value=" PWL( 0 0 100n 0 100.001n 3.3)"}
C {devices/code_shown.sym} 2110 -810 0 1 {name=NGSPICE1 only_toplevel=true
value="
.control
save all
tran 10n 50u 
plot v(VCO_op) v(VCO_op_bar)+4
**write pll_4.raw
.endc
"}
C {devices/vsource.sym} 710 -1030 0 0 {name=V4 value=3.3}
C {devices/vsource.sym} 790 -1030 0 0 {name=V5 value=0}
C {devices/lab_wire.sym} 790 -1080 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 710 -990 0 0 {name=p8 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 710 -1080 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 790 -980 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 2090 -470 0 0 {name=p12 sig_type=std_logic lab=VDD_VCO}
C {devices/lab_pin.sym} 2300 -420 2 0 {name=p13 sig_type=std_logic lab=VCO_op_bar
}
C {devices/lab_pin.sym} 1120 -130 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1120 -110 3 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 700 -860 2 0 {name=p16 sig_type=std_logic lab=VDD_VCO}
C {devices/lab_pin.sym} 900 -800 2 0 {name=p17 sig_type=std_logic lab=Vref
}
C {devices/lab_wire.sym} 670 -550 0 0 {name=p18 sig_type=std_logic lab=VSS
}
C {devices/vsource.sym} 670 -590 0 0 {name=V6 value=" PWL( 0 0 10n 0 10.001n 3)"}
C {devices/lab_pin.sym} 1540 -420 1 0 {name=p19 sig_type=std_logic lab=LP_op_test
}
C {devices/lab_pin.sym} 910 -460 1 0 {name=p20 sig_type=std_logic lab=PU}
C {devices/lab_pin.sym} 910 -410 1 0 {name=p21 sig_type=std_logic lab=PD}
C {Feedback_Divider.sym} 1310 -150 2 0 {name=x2}
C {devices/lab_pin.sym} 1490 -170 2 0 {name=p22 sig_type=std_logic lab=F0}
C {devices/lab_pin.sym} 1490 -150 2 0 {name=p23 sig_type=std_logic lab=F1}
C {devices/lab_pin.sym} 1490 -130 2 0 {name=p24 sig_type=std_logic lab=F2}
C {devices/vsource.sym} 1030 -1010 0 0 {name=V7 value=3.3}
C {devices/lab_wire.sym} 1030 -970 0 0 {name=p26 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1030 -1060 0 0 {name=p27 sig_type=std_logic lab=F1}
C {devices/vsource.sym} 890 -1030 0 0 {name=V8 value=3.3}
C {devices/lab_wire.sym} 890 -990 0 0 {name=p25 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 890 -1080 0 0 {name=p29 sig_type=std_logic lab=F0}
C {devices/vsource.sym} 1130 -1010 0 0 {name=V9 value=3.3}
C {devices/lab_wire.sym} 1130 -970 0 0 {name=p30 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1130 -1060 0 0 {name=p31 sig_type=std_logic lab=F2}
C {devices/lab_pin.sym} 2990 -550 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2990 -570 2 0 {name=p33 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2620 -610 0 0 {name=p82 sig_type=std_logic lab=OPA0}
C {devices/lab_wire.sym} 2630 -640 0 0 {name=p83 sig_type=std_logic lab=OPA1}
C {devices/lab_pin.sym} 2640 -620 2 0 {name=p34 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 3000 -530 2 0 {name=p84 sig_type=std_logic lab=Output1}
C {devices/lab_pin.sym} 3020 -320 0 1 {name=p85 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3000 -340 0 1 {name=p86 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2640 -240 2 1 {name=p87 sig_type=std_logic lab=OPB1}
C {devices/lab_wire.sym} 2650 -210 2 1 {name=p88 sig_type=std_logic lab=OPB0}
C {devices/lab_pin.sym} 3010 -300 0 1 {name=p90 sig_type=std_logic lab=Output2}
C {Output_Divider.sym} 2840 -310 0 0 {name=x5}
C {devices/lab_pin.sym} 2670 -340 1 0 {name=p35 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 2660 -230 2 0 {name=p37 sig_type=std_logic lab=VCO_op
}
C {devices/lab_pin.sym} 2620 -510 2 1 {name=p40 sig_type=std_logic lab=VCO_op
}
C {devices/vsource.sym} 1250 -1000 0 0 {name=V10 value=3.3}
C {devices/lab_wire.sym} 1250 -960 0 0 {name=p41 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1250 -1050 0 0 {name=p42 sig_type=std_logic lab=OPA0}
C {devices/vsource.sym} 1350 -1000 0 0 {name=V11 value=3.3}
C {devices/lab_wire.sym} 1350 -960 0 0 {name=p43 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1350 -1050 0 0 {name=p44 sig_type=std_logic lab=OPA1}
C {devices/vsource.sym} 1430 -1000 0 0 {name=V12 value=3.3}
C {devices/lab_wire.sym} 1430 -960 0 0 {name=p45 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1430 -1050 0 0 {name=p46 sig_type=std_logic lab=OPB0
}
C {devices/vsource.sym} 1530 -1000 0 0 {name=V13 value=0}
C {devices/lab_wire.sym} 1530 -960 0 0 {name=p47 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1530 -1050 0 0 {name=p48 sig_type=std_logic lab=OPB1}
C {devices/lab_pin.sym} 670 -630 2 0 {name=p38 sig_type=std_logic lab=RST_DIV}
C {devices/lab_pin.sym} 1480 -110 2 0 {name=p39 sig_type=std_logic lab=RST_DIV}
C {devices/lab_wire.sym} 1410 -320 2 0 {name=p49 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1410 -520 2 0 {name=p50 sig_type=std_logic lab=VDD}
C {CP.sym} 830 -220 0 0 {name=x6}
C {LF.sym} 1420 -240 0 0 {name=x7}
C {devices/lab_wire.sym} 1560 -270 2 0 {name=p51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1380 -510 0 0 {name=p52 sig_type=std_logic lab=IPD+}
C {devices/lab_wire.sym} 1380 -320 0 0 {name=p53 sig_type=std_logic lab=IPD_}
C {devices/isource.sym} 1050 -840 0 0 {name=I0 value=20u}
C {devices/isource.sym} 1120 -840 0 0 {name=I1 value=20u}
C {devices/lab_wire.sym} 1050 -890 0 0 {name=p54 sig_type=std_logic lab=IPD_}
C {devices/lab_wire.sym} 1120 -790 2 0 {name=p55 sig_type=std_logic lab=IPD+}
C {devices/lab_wire.sym} 1050 -790 2 0 {name=p56 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -890 2 0 {name=p57 sig_type=std_logic lab=VDD}
C {Output_Divider.sym} 2820 -540 0 0 {name=x4}
C {devices/code_shown.sym} 1210 -790 0 0 {name=MODELS2 only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
"}
C {devices/lab_pin.sym} 1540 -400 0 0 {name=p59 sig_type=std_logic lab=VDD}
C {VCO_smb_old.sym} 2290 -430 0 0 {name=x8}
C {Prescalar_Divider.sym} 350 -450 2 1 {name=x1}
C {devices/lab_wire.sym} 680 -780 2 0 {name=p5 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 890 -670 2 0 {name=p6 sig_type=std_logic lab=VSS
}
C {devices/lab_pin.sym} 460 -460 0 0 {name=p58 sig_type=std_logic lab=Vref
}
C {2x1_mux.sym} 790 -410 0 0 {name=x9}
C {2x1_mux.sym} 800 -210 0 0 {name=x10}
C {devices/lab_pin.sym} 960 -540 0 0 {name=p60 sig_type=std_logic lab=PU_test
}
C {devices/lab_pin.sym} 990 -360 1 0 {name=p61 sig_type=std_logic lab=PD_test
}
C {devices/lab_pin.sym} 1040 -600 2 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1050 -400 2 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1050 -260 2 0 {name=p64 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1040 -460 2 0 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1020 -600 1 0 {name=p106 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 1030 -400 1 0 {name=p66 sig_type=std_logic lab=S1}
C {2x1_mux.sym} 810 0 3 0 {name=x11}
C {devices/lab_wire.sym} 760 -250 2 0 {name=p67 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 620 -250 2 1 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 610 -230 0 0 {name=p69 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 680 -170 0 0 {name=p70 sig_type=std_logic lab=Vdiv_test
}
C {devices/vsource.sym} 1660 -1000 0 0 {name=V14 value=3.3}
C {devices/lab_wire.sym} 1660 -960 0 0 {name=p71 sig_type=std_logic lab=VSS
}
C {devices/lab_wire.sym} 1660 -1050 0 0 {name=p72 sig_type=std_logic lab=S1}
C {A_MUX.sym} 1840 -420 0 0 {name=x12}
C {devices/lab_pin.sym} 1840 -480 2 0 {name=p73 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1840 -340 2 0 {name=p74 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1670 -380 2 0 {name=p75 sig_type=std_logic lab=S1}
C {devices/lab_pin.sym} 1670 -480 0 0 {name=p76 sig_type=std_logic lab=vcntl_test
}
