v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 280 -50 300 -50 {
lab=VSS}
N 280 -30 300 -30 {
lab=VDD}
N -30 -30 -20 -30 {
lab=#net1}
N -30 -30 -30 10 {
lab=#net1}
N -30 10 -20 10 {
lab=#net1}
N 280 60 300 60 {
lab=VSS}
N 280 80 300 80 {
lab=VDD}
N -30 80 -20 80 {
lab=#net2}
N -30 80 -30 120 {
lab=#net2}
N -30 120 -20 120 {
lab=#net2}
N 280 190 300 190 {
lab=VSS}
N 280 210 300 210 {
lab=VDD}
N -30 210 -20 210 {
lab=#net3}
N -30 210 -30 250 {
lab=#net3}
N -30 250 -20 250 {
lab=#net3}
N 280 320 300 320 {
lab=VSS}
N 280 340 300 340 {
lab=VDD}
N -30 340 -20 340 {
lab=#net4}
N -30 340 -30 380 {
lab=#net4}
N -30 380 -20 380 {
lab=#net4}
N -40 -50 -20 -50 {
lab=CLK}
N -40 -50 -40 60 {
lab=CLK}
N -40 60 -20 60 {
lab=CLK}
N -40 60 -40 190 {
lab=CLK}
N -40 190 -20 190 {
lab=CLK}
N -40 190 -40 320 {
lab=CLK}
N -40 320 -20 320 {
lab=CLK}
N -50 -10 -20 -10 {
lab=RST}
N -50 -10 -50 100 {
lab=RST}
N -50 100 -20 100 {
lab=RST}
N -50 100 -50 230 {
lab=RST}
N -50 230 -20 230 {
lab=RST}
N -50 230 -50 360 {
lab=RST}
N -50 360 -20 360 {
lab=RST}
N -80 -30 -30 -30 {
lab=#net1}
N -410 -70 -380 -70 {
lab=#net5}
N -540 -40 -540 -20 {
lab=VDD}
N -540 80 -540 110 {
lab=VSS}
N -400 -50 -380 -50 {
lab=#net6}
N -400 -50 -400 30 {
lab=#net6}
N -430 30 -400 30 {
lab=#net6}
N -650 30 -610 30 {
lab=#net7}
N -90 120 -30 120 {
lab=#net2}
N -100 380 -30 380 {
lab=#net4}
N -100 250 -30 250 {
lab=#net3}
N -450 210 -410 210 {
lab=#net8}
N 280 360 290 360 {
lab=Q0}
N 290 300 290 360 {
lab=Q0}
N -400 300 290 300 {
lab=Q0}
N -400 230 -400 300 {
lab=Q0}
N 280 250 280 270 {
lab=#net9}
N -410 270 280 270 {
lab=#net9}
N -410 270 -410 340 {
lab=#net9}
N -410 340 -400 340 {
lab=#net9}
N 280 10 290 10 {
lab=#net10}
N 290 10 290 280 {
lab=#net10}
N -420 280 290 280 {
lab=#net10}
N -420 280 -420 360 {
lab=#net10}
N -420 360 -400 360 {
lab=#net10}
N 280 -10 290 -10 {
lab=Q3}
N 290 -140 290 -10 {
lab=Q3}
N -710 -140 290 -140 {
lab=Q3}
N -710 -140 -710 -110 {
lab=Q3}
N -980 -110 -710 -110 {
lab=Q3}
N -980 -110 -980 170 {
lab=Q3}
N -980 170 -750 170 {
lab=Q3}
N 280 230 310 230 {
lab=Q1}
N 310 140 310 230 {
lab=Q1}
N -960 140 310 140 {
lab=Q1}
N -960 30 -960 140 {
lab=Q1}
N -960 10 -960 30 {
lab=Q1}
N -960 10 -950 10 {
lab=Q1}
N -760 190 -750 190 {
lab=Q1}
N -760 140 -760 190 {
lab=Q1}
N -410 230 -400 230 {
lab=Q0}
N -420 230 -410 230 {
lab=Q0}
N -420 100 -420 230 {
lab=Q0}
N -420 100 -390 100 {
lab=Q0}
N -410 210 -400 210 {
lab=#net8}
N -400 80 -390 80 {
lab=Q1}
N -400 80 -400 140 {
lab=Q1}
N -950 30 -950 100 {
lab=Q0}
N -950 100 -420 100 {
lab=Q0}
N -960 -90 -960 10 {
lab=Q1}
N -960 -90 -710 -90 {
lab=Q1}
N 370 50 370 70 {
lab=Q2}
N 370 50 380 50 {
lab=Q2}
N 360 30 380 30 {
lab=CLK}
N -40 30 360 30 {
lab=CLK}
N 280 100 300 100 {
lab=Q2}
N 300 100 300 150 {
lab=Q2}
N -970 150 300 150 {
lab=Q2}
N -970 -10 -970 150 {
lab=Q2}
N -970 -10 -950 -10 {
lab=Q2}
N 300 100 370 100 {
lab=Q2}
N 370 70 370 100 {
lab=Q2}
N 370 100 370 120 {
lab=Q2}
N 370 120 390 120 {
lab=Q2}
N 390 140 390 230 {
lab=Q1}
N 310 230 390 230 {
lab=Q1}
N 1290 10 1290 70 {
lab=Q3}
N 1590 110 1620 110 {
lab=#net11}
N -410 -110 -390 -110 {
lab=VSS}
N -410 -90 -390 -90 {
lab=VDD}
N -80 -70 -60 -70 {
lab=VSS}
N -80 -50 -60 -50 {
lab=VDD}
N -650 -10 -630 -10 {
lab=VSS}
N -650 10 -630 10 {
lab=VDD}
N -450 170 -430 170 {
lab=VSS}
N -450 190 -430 190 {
lab=VDD}
N -100 210 -80 210 {
lab=VSS}
N -100 230 -80 230 {
lab=VDD}
N -100 340 -80 340 {
lab=VSS}
N -100 360 -80 360 {
lab=VDD}
N -90 80 -70 80 {
lab=VSS}
N -90 100 -70 100 {
lab=VDD}
N 690 120 710 120 {
lab=VSS}
N 690 140 710 140 {
lab=VDD}
N 1590 70 1610 70 {
lab=VSS}
N 1590 90 1610 90 {
lab=VDD}
N -540 -40 -520 -40 {
lab=VDD}
N 1620 110 1650 110 {
lab=Vdiv11}
N 1240 90 1290 90 {
lab=#net12}
N 290 -10 920 -10 {
lab=Q3}
N 690 160 940 160 {
lab=#net13}
N 920 -10 1290 -10 {
lab=Q3}
N 1290 -10 1290 10 {
lab=Q3}
N 940 160 1240 160 {
lab=#net13}
N 380 50 390 50 {
lab=Q2}
N 690 340 710 340 {
lab=VSS}
N 690 360 710 360 {
lab=VDD}
N 370 120 370 200 {
lab=Q2}
N 370 200 370 210 {
lab=Q2}
N 370 210 370 340 {
lab=Q2}
N 370 340 390 340 {
lab=Q2}
N 290 360 390 360 {
lab=Q0}
N 710 30 730 30 {
lab=VSS}
N 710 50 730 50 {
lab=VDD}
N 380 30 410 30 {
lab=CLK}
N 390 50 410 50 {
lab=Q2}
N 710 70 1240 70 {}
N 1240 70 1240 90 {}
N 1240 110 1240 160 {}
N 1240 110 1290 110 {}
N 690 380 1290 380 {}
N 1290 130 1290 380 {}
C {JK_flipflop.sym} 130 -20 0 0 {name=x1}
C {devices/lab_pin.sym} 300 -50 2 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 300 -30 2 0 {name=p11 sig_type=std_logic lab=VDD}
C {JK_flipflop.sym} 130 90 0 0 {name=x2}
C {devices/lab_pin.sym} 300 60 2 0 {name=p1 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 300 80 2 0 {name=p2 sig_type=std_logic lab=VDD}
C {JK_flipflop.sym} 130 220 0 0 {name=x3}
C {devices/lab_pin.sym} 300 190 2 0 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 300 210 2 0 {name=p4 sig_type=std_logic lab=VDD}
C {JK_flipflop.sym} 130 350 0 0 {name=x4}
C {devices/lab_pin.sym} 300 320 2 0 {name=p5 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 300 340 2 0 {name=p6 sig_type=std_logic lab=VDD}
C {or_2.sym} -230 -50 0 0 {name=x5}
C {GF_INV.sym} -540 30 0 0 {name=x7}
C {nand_3.sym} -800 10 0 0 {name=x8}
C {or_2.sym} -250 360 0 0 {name=x10}
C {or_2.sym} -250 230 0 0 {name=x11}
C {devices/ipin.sym} -340 -190 0 0 {name=p9 lab=CLK}
C {devices/iopin.sym} -310 -190 0 0 {name=p12 lab=VSS
}
C {devices/iopin.sym} -240 -190 0 0 {name=p13 lab=VDD}
C {devices/opin.sym} -170 -190 0 0 {name=p14 lab=Q0}
C {devices/opin.sym} -100 -190 0 0 {name=p27 lab=Q1}
C {devices/ipin.sym} -540 -190 0 0 {name=p30 lab=RST}
C {devices/opin.sym} 80 -190 0 0 {name=p18 lab=Vdiv11}
C {devices/opin.sym} -50 -190 0 0 {name=p16 lab=Q2}
C {devices/opin.sym} 20 -190 0 0 {name=p17 lab=Q3}
C {devices/lab_pin.sym} -390 -110 2 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -390 -90 2 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -60 -70 2 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -60 -50 2 0 {name=p19 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -630 -10 2 0 {name=p20 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -630 10 2 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -430 170 2 0 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -430 190 2 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -80 210 2 0 {name=p24 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -80 230 2 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -80 340 2 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -80 360 2 0 {name=p28 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -70 80 2 0 {name=p29 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -70 100 2 0 {name=p31 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 710 120 2 0 {name=p34 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 710 140 2 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1610 70 2 0 {name=p36 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1610 90 2 0 {name=p37 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -540 110 2 0 {name=p38 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -520 -40 2 0 {name=p39 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 370 -10 1 0 {name=p46 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 320 100 3 0 {name=p47 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 310 230 3 0 {name=p48 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 290 360 2 0 {name=p49 sig_type=std_logic lab=Q0}
C {devices/lab_pin.sym} -40 290 2 0 {name=p50 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} -50 -10 0 0 {name=p51 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} 1650 110 2 0 {name=p52 sig_type=std_logic lab=Vdiv11}
C {and_2.sym} -560 -90 0 0 {name=x6}
C {and_2.sym} -600 190 0 0 {name=x12}
C {and_2.sym} 540 140 0 0 {name=x15}
C {and_2.sym} -240 100 0 0 {name=x9}
C {devices/lab_pin.sym} 710 340 2 0 {name=p32 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 710 360 2 0 {name=p33 sig_type=std_logic lab=VDD}
C {and_2.sym} 540 360 0 0 {name=x13}
C {devices/lab_pin.sym} 730 30 2 0 {name=p40 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 730 50 2 0 {name=p41 sig_type=std_logic lab=VDD}
C {and_2.sym} 560 50 0 0 {name=x14}
C {or_4.sym} 1440 100 0 0 {name=x16}
