v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 150 -290 320 -290 {
lab=VSS}
N 400 -210 410 -210 {
lab=OPB1}
N 320 -110 460 -110 {
lab=VDD}
N 460 -110 460 -90 {
lab=VDD}
N 230 -190 240 -190 {
lab=#net1}
N 230 -270 230 -190 {
lab=#net1}
N 150 -270 230 -270 {
lab=#net1}
N 220 -210 240 -210 {
lab=#net2}
N 150 -190 220 -190 {
lab=#net2}
N 210 -230 240 -230 {
lab=#net3}
N 210 -230 210 -70 {
lab=#net3}
N 150 -70 210 -70 {
lab=#net3}
N 90 30 240 30 {
lab=#net4}
N 240 -170 240 30 {
lab=#net4}
N -20 -290 -20 110 {
lab=VSS}
N -30 -90 -20 -90 {
lab=VSS}
N -30 -210 -20 -210 {
lab=VSS}
N 350 -30 360 -30 {
lab=#net5}
N 170 10 360 10 {
lab=#net6}
N 170 -210 170 -20 {
lab=#net6}
N 150 -250 170 -250 {
lab=#net6}
N 150 -130 180 -130 {
lab=#net7}
N 180 -120 180 0 {
lab=#net7}
N 180 50 360 50 {
lab=#net7}
N 150 -30 190 -30 {
lab=#net8}
N 190 -10 190 20 {
lab=#net8}
N 190 90 360 90 {
lab=#net8}
N -340 -290 -330 -290 {
lab=RST}
N -350 -270 -330 -270 {
lab=CLK}
N -340 -310 -340 -290 {
lab=RST}
N -370 -270 -350 -270 {
lab=CLK}
N -340 -290 -340 -90 {
lab=RST}
N -340 -90 -330 -90 {
lab=RST}
N -340 -210 -330 -210 {
lab=RST}
N -350 -270 -350 -160 {
lab=CLK}
N -350 -190 -330 -190 {
lab=CLK}
N -350 -160 -350 -70 {
lab=CLK}
N -350 -70 -330 -70 {
lab=CLK}
N -350 -70 -350 70 {
lab=CLK}
N -350 70 -130 70 {
lab=CLK}
N 530 10 540 10 {
lab=Vdiv}
N 320 -290 330 -290 {
lab=VSS}
N 320 -110 320 -100 {
lab=VDD}
N 410 -210 430 -210 {
lab=OPB1}
N 400 -190 420 -190 {
lab=OPB0}
N 410 -210 410 -100 {
lab=OPB1}
N 430 -190 430 -100 {
lab=OPB0}
N 420 -190 430 -190 {
lab=OPB0}
N 170 -250 170 -210 {
lab=#net6}
N 220 -210 220 -190 {
lab=#net2}
N 180 -130 180 -120 {
lab=#net7}
N 190 -30 190 -10 {
lab=#net8}
N -20 140 -20 540 {
lab=VSS}
N -30 340 -20 340 {
lab=VSS}
N -30 220 -20 220 {
lab=VSS}
N 150 180 170 180 {
lab=#net9}
N -340 140 -330 140 {
lab=RST}
N -350 160 -330 160 {
lab=CLKB}
N -340 120 -340 140 {
lab=RST}
N -370 160 -350 160 {
lab=CLKB}
N -340 140 -340 340 {
lab=RST}
N -340 340 -330 340 {
lab=RST}
N -340 220 -330 220 {
lab=RST}
N -350 160 -350 270 {
lab=CLKB}
N -350 240 -330 240 {
lab=CLKB}
N -350 270 -350 360 {
lab=CLKB}
N -350 360 -330 360 {
lab=CLKB}
N -350 360 -350 500 {
lab=CLKB}
N -350 500 -130 500 {
lab=CLKB}
N -30 140 -20 140 {
lab=VSS}
N -20 110 -20 140 {
lab=VSS}
N 230 -190 230 160 {
lab=#net1}
N 150 160 230 160 {
lab=#net1}
N 220 -190 220 240 {
lab=#net2}
N 150 240 220 240 {
lab=#net2}
N 210 -70 210 360 {
lab=#net3}
N 150 360 210 360 {
lab=#net3}
N 240 30 240 460 {
lab=#net4}
N 90 460 240 460 {
lab=#net4}
N -90 540 -20 540 {
lab=VSS}
N 530 30 540 30 {
lab=VdivB}
N -90 110 -20 110 {
lab=VSS}
N 440 160 440 170 {
lab=VSS}
N 160 170 440 170 {
lab=VSS}
N 320 -30 320 70 {
lab=#net5}
N 170 -20 170 10 {
lab=#net6}
N 180 0 180 50 {
lab=#net7}
N 190 20 190 90 {
lab=#net8}
N 150 500 340 500 {
lab=#net10}
N 340 -10 340 500 {
lab=#net10}
N 340 -10 360 -10 {
lab=#net10}
N 170 180 330 180 {
lab=#net9}
N 330 30 330 180 {
lab=#net9}
N 330 30 360 30 {
lab=#net9}
N 150 70 320 70 {
lab=#net5}
N 320 -30 350 -30 {
lab=#net5}
N 350 70 360 70 {
lab=#net11}
N 350 70 350 300 {
lab=#net11}
N 150 300 350 300 {
lab=#net11}
N 320 110 360 110 {
lab=#net12}
N 320 110 320 400 {
lab=#net12}
N 150 400 320 400 {
lab=#net12}
N -30 -250 -10 -250 {
lab=#net13}
N -30 -130 -10 -130 {
lab=#net14}
N -30 -30 -10 -30 {
lab=#net15}
N -30 -300 140 -300 {
lab=VSS}
N 140 -300 150 -300 {
lab=VSS}
N -30 -300 -30 -290 {
lab=VSS}
N -30 -290 -20 -290 {
lab=VSS}
N 150 -300 150 -290 {
lab=VSS}
N -30 -270 -10 -270 {
lab=#net1}
N -10 -290 -10 -270 {
lab=#net1}
N -10 -290 30 -290 {
lab=#net1}
N 30 -290 140 -290 {
lab=#net1}
N 140 -290 140 -270 {
lab=#net1}
N 140 -270 150 -270 {
lab=#net1}
N -90 30 90 30 {
lab=#net4}
N -90 460 90 460 {
lab=#net4}
N -30 500 150 500 {
lab=#net10}
N 90 -250 150 -250 {
lab=#net6}
N 90 -130 150 -130 {
lab=#net7}
N 90 -30 150 -30 {
lab=#net8}
N -30 160 150 160 {
lab=#net1}
N -30 70 150 70 {
lab=#net5}
N -30 180 150 180 {
lab=#net9}
N -30 240 150 240 {
lab=#net2}
N -30 -190 150 -190 {
lab=#net2}
N -30 -70 150 -70 {
lab=#net3}
N -30 300 150 300 {
lab=#net11}
N -30 360 150 360 {
lab=#net3}
N -30 400 150 400 {
lab=#net12}
N -20 170 160 170 {
lab=VSS}
N -10 -250 90 -250 {}
N -10 -130 90 -130 {}
N -10 -30 90 -30 {}
C {decoder_2x4.sym} 660 -390 2 0 {name=x5}
C {devices/ipin.sym} -10 -340 0 0 {name=p9 lab=CLK}
C {devices/iopin.sym} 10 -340 0 0 {name=p12 lab=VSS
}
C {devices/iopin.sym} 80 -340 0 0 {name=p13 lab=VDD}
C {devices/ipin.sym} -80 -340 0 0 {name=p30 lab=RST}
C {devices/opin.sym} 160 -340 0 0 {name=p18 lab=Vdiv}
C {devices/ipin.sym} -170 -340 0 0 {name=p4 lab=OPB1}
C {devices/ipin.sym} -280 -340 0 0 {name=p8 lab=OPB0}
C {buffer.sym} -150 180 0 0 {name=x6}
C {devices/lab_pin.sym} -340 -310 0 0 {name=p5 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} -370 -270 0 0 {name=p6 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 540 10 2 0 {name=p7 sig_type=std_logic lab=Vdiv}
C {devices/lab_pin.sym} 330 -290 2 0 {name=p1 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 320 -100 3 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 410 -210 2 0 {name=p10 sig_type=std_logic lab=OPB1}
C {devices/lab_pin.sym} 420 -190 2 0 {name=p14 sig_type=std_logic lab=OPB0}
C {CLK_div_2.sym} -180 -270 0 0 {name=x1}
C {CLK_div_3.sym} -180 -170 0 0 {name=x2}
C {CLK_div_4.sym} -180 -60 0 0 {name=x3}
C {buffer.sym} -150 610 0 0 {name=x7}
C {devices/lab_pin.sym} -340 120 0 0 {name=p3 sig_type=std_logic lab=RST}
C {devices/lab_pin.sym} -370 160 0 0 {name=p11 sig_type=std_logic lab=CLKB}
C {diff_mux_4x1.sym} -250 270 0 0 {name=x11}
C {devices/lab_pin.sym} 540 30 2 0 {name=p15 sig_type=std_logic lab=VdivB}
C {devices/ipin.sym} 300 -340 0 0 {name=p16 lab=CLKB}
C {devices/opin.sym} 320 -340 0 0 {name=p17 lab=VdivB}
C {Diff_Clk_div_2.sym} -180 160 0 0 {name=x4}
C {Diff_CLK_div_3.sym} -180 260 0 0 {name=x8}
C {Diff_CLK_div_4.sym} -180 370 0 0 {name=x9}
