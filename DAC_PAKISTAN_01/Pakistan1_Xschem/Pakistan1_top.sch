v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 2180 -1140 3010 -1140 {
lab=VSS}
N 2180 -1310 3020 -1310 {
lab=VSS}
N 2180 -1490 3020 -1490 {
lab=VSS}
N 710 -1490 2180 -1490 {
lab=VSS}
N 970 -1700 3010 -1700 {
lab=VSS}
N 970 -1900 1800 -1900 {
lab=VSS}
N 1800 -1900 2740 -1900 {
lab=VSS}
N 1520 -1310 2180 -1310 {
lab=VSS}
N 720 -1310 1520 -1310 {
lab=VSS}
N 710 -1310 720 -1310 {
lab=VSS}
N 960 -90 960 -70 {
lab=VSS}
N 960 -70 2710 -70 {
lab=VSS}
N 2710 -70 2730 -70 {
lab=VSS}
N 1230 -90 1230 -70 {
lab=VSS}
N 1490 -100 1490 -70 {
lab=VSS}
N 1800 -80 1800 -70 {
lab=VSS}
N 690 -290 690 -270 {
lab=VSS}
N 690 -270 3000 -270 {
lab=VSS}
N 960 -290 960 -270 {
lab=VSS}
N 1230 -290 1230 -270 {
lab=VSS}
N 1490 -300 1490 -270 {
lab=VSS}
N 1810 -280 1810 -270 {
lab=VSS}
N 2160 -280 2160 -270 {
lab=VSS}
N 690 -510 3000 -510 {
lab=VSS}
N 710 -740 3020 -740 {
lab=VSS}
N 710 -940 3020 -940 {
lab=VSS}
N 980 -950 980 -940 {
lab=VSS}
N 1840 -1030 1840 -940 {
lab=VSS}
N 710 -1120 1520 -1120 {
lab=VSS}
N 1520 -1140 1520 -1120 {
lab=VSS}
N 1250 -1130 1250 -1120 {
lab=VSS}
N 990 -2060 990 -2030 {
lab=VDD}
N 990 -2060 2760 -2060 {
lab=VDD}
N 2760 -2060 2760 -2030 {
lab=VDD}
N 990 -1840 990 -1830 {
lab=VDD}
N 990 -1850 990 -1840 {
lab=VDD}
N 990 -1850 3030 -1850 {
lab=VDD}
N 3030 -1850 3030 -1830 {
lab=VDD}
N 1260 -2060 1260 -2030 {
lab=VDD}
N 1510 -2060 1510 -2020 {
lab=VDD}
N 1840 -2060 1840 -2030 {
lab=VDD}
N 2180 -2060 2180 -2030 {
lab=VDD}
N 2460 -2060 2460 -2020 {
lab=VDD}
N 2750 -1850 2750 -1830 {
lab=VDD}
N 2480 -1850 2480 -1830 {
lab=VDD}
N 2170 -1850 2170 -1820 {
lab=VDD}
N 1840 -1850 1840 -1830 {
lab=VDD}
N 1520 -1850 1520 -1820 {
lab=VDD}
N 1260 -1850 1260 -1830 {
lab=VDD}
N 730 -1640 730 -1620 {
lab=VDD}
N 730 -1640 3040 -1640 {
lab=VDD}
N 3040 -1640 3040 -1620 {
lab=VDD}
N 1000 -1640 1000 -1620 {
lab=VDD}
N 1260 -1640 1260 -1620 {
lab=VDD}
N 1540 -1640 1540 -1620 {
lab=VDD}
N 1860 -1640 1860 -1620 {
lab=VDD}
N 2200 -1640 2200 -1620 {
lab=VDD}
N 2470 -1640 2470 -1620 {
lab=VDD}
N 2770 -1640 2770 -1620 {
lab=VDD}
N 710 -1450 710 -1430 {
lab=VDD}
N 710 -1450 3020 -1450 {
lab=VDD}
N 3020 -1450 3020 -1430 {
lab=VDD}
N 2750 -1450 2750 -1430 {
lab=VDD}
N 2470 -1450 2470 -1440 {
lab=VDD}
N 1860 -1450 1860 -1440 {
lab=VDD}
N 2180 -1450 2180 -1430 {
lab=VDD}
N 1520 -1450 1520 -1430 {
lab=VDD}
N 1260 -1450 1260 -1440 {
lab=VDD}
N 980 -1450 980 -1430 {
lab=VDD}
N 730 -1260 730 -1250 {
lab=VDD}
N 730 -1270 730 -1260 {
lab=VDD}
N 730 -1280 730 -1270 {
lab=VDD}
N 730 -1280 1540 -1280 {
lab=VDD}
N 1540 -1280 1540 -1270 {
lab=VDD}
N 1540 -1280 3030 -1280 {
lab=VDD}
N 3030 -1280 3030 -1270 {
lab=VDD}
N 2760 -1280 2760 -1270 {
lab=VDD}
N 2460 -1280 2460 -1270 {
lab=VDD}
N 2200 -1280 2200 -1270 {
lab=VDD}
N 1250 -950 1250 -940 {
lab=VSS}
N 730 -1090 730 -1070 {
lab=VDD}
N 730 -1090 1540 -1090 {
lab=VDD}
N 1540 -1090 1540 -1070 {
lab=VDD}
N 1270 -1090 1270 -1080 {
lab=VDD}
N 2210 -1090 2210 -1070 {
lab=VDD}
N 2210 -1090 3040 -1090 {
lab=VDD}
N 3040 -1090 3040 -1070 {
lab=VDD}
N 2470 -1090 2470 -1070 {
lab=VDD}
N 2770 -1080 2770 -1070 {
lab=VDD}
N 2770 -1090 2770 -1080 {
lab=VDD}
N 730 -890 730 -870 {
lab=VDD}
N 730 -890 3020 -890 {
lab=VDD}
N 3020 -890 3020 -860 {
lab=VDD}
N 2750 -890 2750 -860 {
lab=VDD}
N 2480 -890 2480 -870 {
lab=VDD}
N 2190 -890 2190 -860 {
lab=VDD}
N 1860 -890 1860 -870 {
lab=VDD}
N 1520 -890 1520 -860 {
lab=VDD}
N 1270 -890 1270 -870 {
lab=VDD}
N 980 -890 980 -860 {
lab=VDD}
N 710 -670 710 -640 {
lab=VDD}
N 710 -670 3020 -670 {
lab=VDD}
N 3020 -670 3020 -640 {
lab=VDD}
N 2750 -670 2750 -640 {
lab=VDD}
N 2470 -670 2470 -640 {
lab=VDD}
N 2180 -670 2180 -640 {
lab=VDD}
N 1840 -670 1840 -640 {
lab=VDD}
N 1510 -670 1510 -640 {
lab=VDD}
N 1250 -670 1250 -640 {
lab=VDD}
N 980 -670 980 -640 {
lab=VDD}
N 710 -440 710 -420 {
lab=VDD}
N 710 -440 3020 -440 {
lab=VDD}
N 3020 -440 3020 -400 {
lab=VDD}
N 980 -240 980 -220 {
lab=VDD}
N 980 -240 2750 -240 {
lab=VDD}
N 2750 -240 2750 -200 {
lab=VDD}
N 2450 -240 2450 -190 {
lab=VDD}
N 2170 -240 2170 -200 {
lab=VDD}
N 1820 -240 1820 -210 {
lab=VDD}
N 1490 -240 1490 -220 {
lab=VDD}
N 1250 -240 1250 -220 {
lab=VDD}
N 1000 -1280 1000 -1250 {
lab=VDD}
N 1270 -1280 1270 -1260 {
lab=VDD}
N 1850 -1280 1850 -1230 {
lab=VDD}
N 980 -440 980 -420 {
lab=VDD}
N 1250 -440 1250 -420 {
lab=VDD}
N 1490 -440 1490 -420 {
lab=VDD}
N 1830 -440 1830 -410 {
lab=VDD}
N 2160 -440 2160 -400 {
lab=VDD}
N 2470 -440 2470 -400 {
lab=VDD}
N 2750 -440 2750 -400 {
lab=VDD}
N 1910 -1030 1910 -910 {
lab=C32_U}
N 1910 -910 2090 -910 {
lab=C32_U}
N 2090 -910 2090 -810 {
lab=C32_U}
N 2090 -810 2100 -810 {
lab=C32_U}
N 1890 -1030 1890 -900 {
lab=C32_D}
N 1890 -900 2070 -900 {
lab=C32_D}
N 2070 -900 2070 -790 {
lab=C32_D}
N 2070 -790 2100 -790 {
lab=C32_D}
N 1420 -910 1910 -910 {
lab=C32_U}
N 1420 -910 1420 -810 {
lab=C32_U}
N 1420 -810 1430 -810 {
lab=C32_U}
N 1400 -900 1890 -900 {
lab=C32_D}
N 1400 -900 1400 -790 {
lab=C32_D}
N 1400 -790 1430 -790 {
lab=C32_D}
N 2270 -810 2310 -810 {
lab=#net1}
N 2310 -810 2310 -785 {
lab=#net1}
N 2310 -785 2380 -785 {
lab=#net1}
N 2270 -790 2285 -790 {
lab=#net2}
N 2285 -790 2285 -770 {
lab=#net2}
N 2285 -770 2380 -770 {
lab=#net2}
N 2285 -915 2285 -810 {
lab=#net1}
N 2285 -930 2285 -915 {
lab=#net1}
N 2085 -930 2285 -930 {
lab=#net1}
N 2085 -985 2085 -930 {
lab=#net1}
N 2085 -985 2110 -985 {
lab=#net1}
N 2280 -910 2280 -790 {
lab=#net2}
N 2280 -920 2280 -910 {
lab=#net2}
N 2105 -920 2280 -920 {
lab=#net2}
N 2105 -970 2105 -920 {
lab=#net2}
N 2105 -970 2110 -970 {
lab=#net2}
N 2285 -930 2645 -930 {
lab=#net1}
N 2645 -930 2645 -810 {
lab=#net1}
N 2645 -810 2660 -810 {
lab=#net1}
N 2280 -920 2625 -920 {
lab=#net2}
N 2625 -920 2625 -790 {
lab=#net2}
N 2625 -790 2660 -790 {
lab=#net2}
N 2050 -930 2085 -930 {
lab=#net1}
N 2050 -930 2050 -350 {
lab=#net1}
N 2050 -350 2070 -350 {
lab=#net1}
N 2030 -920 2105 -920 {
lab=#net2}
N 2030 -920 2030 -340 {
lab=#net2}
N 2030 -340 2030 -330 {
lab=#net2}
N 2030 -330 2070 -330 {
lab=#net2}
N 1600 -810 1650 -810 {
lab=#net3}
N 1650 -810 1650 -785 {
lab=#net3}
N 1650 -785 1760 -785 {
lab=#net3}
N 1600 -790 1620 -790 {
lab=#net4}
N 1620 -790 1620 -770 {
lab=#net4}
N 1620 -770 1755 -770 {
lab=#net4}
N 1755 -770 1760 -770 {
lab=#net4}
N 1620 -935 1620 -810 {
lab=#net3}
N 1415 -935 1620 -935 {
lab=#net3}
N 1415 -985 1415 -935 {
lab=#net3}
N 1415 -985 1440 -985 {
lab=#net3}
N 1610 -920 1610 -790 {
lab=#net4}
N 1400 -920 1610 -920 {
lab=#net4}
N 1400 -970 1400 -920 {
lab=#net4}
N 1400 -970 1440 -970 {
lab=#net4}
N 1380 -935 1415 -935 {
lab=#net3}
N 1380 -935 1380 -370 {
lab=#net3}
N 1380 -370 1400 -370 {
lab=#net3}
N 1385 -920 1400 -920 {
lab=#net4}
N 1385 -920 1385 -350 {
lab=#net4}
N 1385 -350 1400 -350 {
lab=#net4}
N 885 -935 1380 -935 {
lab=#net3}
N 885 -935 885 -810 {
lab=#net3}
N 885 -810 890 -810 {
lab=#net3}
N 880 -920 1385 -920 {
lab=#net4}
N 880 -920 880 -790 {
lab=#net4}
N 880 -790 890 -790 {
lab=#net4}
N 2040 -1380 2090 -1380 {
lab=C32_U}
N 2040 -1360 2090 -1360 {
lab=C32_D}
N 1395 -1380 1430 -1380 {
lab=C32_U}
N 1395 -1360 1430 -1360 {
lab=C32_D}
N 2260 -1380 2290 -1380 {
lab=#net5}
N 2290 -1380 2290 -1300 {
lab=#net5}
N 2070 -1300 2290 -1300 {
lab=#net5}
N 2070 -1300 2070 -1185 {
lab=#net5}
N 2070 -1185 2100 -1185 {
lab=#net5}
N 2260 -1360 2275 -1360 {
lab=#net6}
N 2275 -1360 2275 -1295 {
lab=#net6}
N 2080 -1295 2275 -1295 {
lab=#net6}
N 2080 -1295 2080 -1170 {
lab=#net6}
N 2080 -1170 2100 -1170 {
lab=#net6}
N 1730 -1300 2070 -1300 {
lab=#net5}
N 1730 -1355 1730 -1300 {
lab=#net5}
N 1730 -1355 1760 -1355 {
lab=#net5}
N 1755 -1295 2080 -1295 {
lab=#net6}
N 1755 -1340 1755 -1295 {
lab=#net6}
N 1755 -1340 1760 -1340 {
lab=#net6}
N 2290 -1300 2650 -1300 {
lab=#net5}
N 2650 -1380 2650 -1300 {
lab=#net5}
N 2650 -1380 2660 -1380 {
lab=#net5}
N 2275 -1295 2660 -1295 {
lab=#net6}
N 2660 -1360 2660 -1295 {
lab=#net6}
N 2000 -1770 2000 -1300 {
lab=#net5}
N 2000 -1770 2080 -1770 {
lab=#net5}
N 2015 -1750 2015 -1295 {
lab=#net6}
N 2015 -1750 2080 -1750 {
lab=#net6}
N 1600 -1480 1600 -1380 {
lab=#net7}
N 1410 -1480 1600 -1480 {
lab=#net7}
N 1600 -1360 1610 -1360 {
lab=#net8}
N 1610 -1470 1610 -1360 {
lab=#net8}
N 1425 -1470 1610 -1470 {
lab=#net8}
N 1410 -1480 1410 -1185 {
lab=#net7}
N 1410 -1185 1440 -1185 {
lab=#net7}
N 1425 -1470 1425 -1170 {
lab=#net8}
N 1425 -1170 1440 -1170 {
lab=#net8}
N 1125 -1480 1410 -1480 {
lab=#net7}
N 1125 -1480 1125 -1355 {
lab=#net7}
N 1125 -1355 1160 -1355 {
lab=#net7}
N 1150 -1470 1425 -1470 {
lab=#net8}
N 1150 -1470 1150 -1340 {
lab=#net8}
N 1150 -1340 1160 -1340 {
lab=#net8}
N 860 -1480 1125 -1480 {
lab=#net7}
N 860 -1480 860 -1380 {
lab=#net7}
N 860 -1380 890 -1380 {
lab=#net7}
N 880 -1470 1150 -1470 {
lab=#net8}
N 880 -1470 880 -1360 {
lab=#net8}
N 880 -1360 890 -1360 {
lab=#net8}
N 1060 -1380 1100 -1380 {
lab=#net9}
N 1100 -1380 1105 -1380 {
lab=#net9}
N 1105 -1380 1115 -1380 {
lab=#net9}
N 1115 -1380 1115 -1175 {
lab=#net9}
N 1115 -1175 1170 -1175 {
lab=#net9}
N 1060 -1360 1120 -1360 {
lab=#net10}
N 1120 -1360 1120 -1160 {
lab=#net10}
N 1120 -1160 1170 -1160 {
lab=#net10}
N 860 -1295 1115 -1295 {
lab=#net9}
N 860 -1295 860 -1165 {
lab=#net9}
N 860 -1165 900 -1165 {
lab=#net9}
N 875 -1305 1120 -1305 {
lab=#net10}
N 875 -1305 875 -1150 {
lab=#net10}
N 875 -1150 900 -1150 {
lab=#net10}
N 875 -1520 875 -1305 {
lab=#net10}
N 875 -1520 900 -1520 {
lab=#net10}
N 840 -1295 860 -1295 {
lab=#net9}
N 840 -1535 840 -1295 {
lab=#net9}
N 840 -1535 900 -1535 {
lab=#net9}
N 615 -1305 875 -1305 {
lab=#net10}
N 615 -1360 615 -1305 {
lab=#net10}
N 615 -1360 620 -1360 {
lab=#net10}
N 580 -1295 840 -1295 {
lab=#net9}
N 580 -1380 580 -1295 {
lab=#net9}
N 580 -1380 620 -1380 {
lab=#net9}
N 1000 -1090 1000 -1080 {
lab=VDD}
N 980 -520 980 -510 {
lab=VSS}
N 1060 -810 1085 -810 {
lab=#net11}
N 1085 -810 1085 -710 {
lab=#net11}
N 870 -710 1085 -710 {
lab=#net11}
N 870 -710 870 -595 {
lab=#net11}
N 870 -595 870 -590 {
lab=#net11}
N 870 -590 890 -590 {
lab=#net11}
N 1060 -790 1070 -790 {
lab=#net12}
N 1070 -790 1070 -690 {
lab=#net12}
N 885 -690 1070 -690 {
lab=#net12}
N 885 -690 885 -570 {
lab=#net12}
N 885 -570 890 -570 {
lab=#net12}
N 1085 -785 1170 -785 {
lab=#net11}
N 1070 -770 1170 -770 {
lab=#net12}
N 1125 -995 1125 -785 {
lab=#net11}
N 1125 -995 1170 -995 {
lab=#net11}
N 1145 -980 1145 -770 {
lab=#net12}
N 1145 -980 1170 -980 {
lab=#net12}
N 870 -925 1125 -925 {
lab=#net11}
N 870 -995 870 -925 {
lab=#net11}
N 870 -995 900 -995 {
lab=#net11}
N 875 -910 1145 -910 {
lab=#net12}
N 875 -980 875 -910 {
lab=#net12}
N 875 -980 900 -980 {
lab=#net12}
N 1060 -590 1085 -590 {
lab=#net13}
N 1085 -590 1085 -480 {
lab=#net13}
N 860 -480 1085 -480 {
lab=#net13}
N 860 -480 860 -335 {
lab=#net13}
N 860 -335 880 -335 {
lab=#net13}
N 1060 -570 1075 -570 {
lab=#net14}
N 1075 -570 1075 -465 {
lab=#net14}
N 875 -465 1075 -465 {
lab=#net14}
N 845 -465 875 -465 {
lab=#net14}
N 845 -465 845 -320 {
lab=#net14}
N 845 -320 880 -320 {
lab=#net14}
N 565 -480 860 -480 {
lab=#net13}
N 565 -480 565 -335 {
lab=#net13}
N 565 -335 610 -335 {
lab=#net13}
N 585 -465 845 -465 {
lab=#net14}
N 585 -465 585 -320 {
lab=#net14}
N 585 -320 610 -320 {
lab=#net14}
N 565 -780 565 -480 {
lab=#net13}
N 565 -785 565 -780 {
lab=#net13}
N 565 -785 630 -785 {
lab=#net13}
N 585 -770 585 -465 {
lab=#net14}
N 585 -770 630 -770 {
lab=#net14}
N 565 -555 610 -555 {
lab=#net13}
N 585 -540 610 -540 {
lab=#net14}
N 1570 -370 1645 -370 {
lab=#net15}
N 1645 -555 1645 -370 {
lab=#net15}
N 1645 -555 1740 -555 {
lab=#net15}
N 1570 -350 1665 -350 {
lab=#net16}
N 1665 -540 1665 -350 {
lab=#net16}
N 1665 -540 1740 -540 {
lab=#net16}
N 1395 -485 1645 -485 {
lab=#net15}
N 1395 -555 1395 -485 {
lab=#net15}
N 1395 -555 1405 -555 {
lab=#net15}
N 1405 -470 1665 -470 {
lab=#net16}
N 1405 -540 1405 -470 {
lab=#net16}
N 1405 -540 1410 -540 {
lab=#net16}
N 1125 -485 1395 -485 {
lab=#net15}
N 1125 -555 1125 -485 {
lab=#net15}
N 1125 -555 1150 -555 {
lab=#net15}
N 1145 -470 1405 -470 {
lab=#net16}
N 1145 -540 1145 -470 {
lab=#net16}
N 1145 -540 1150 -540 {
lab=#net16}
N 1645 -370 1645 -260 {
lab=#net15}
N 1385 -170 1400 -170 {
lab=#net15}
N 1395 -150 1400 -150 {
lab=#net16}
N 1390 -150 1395 -150 {
lab=#net16}
N 1390 -255 1390 -150 {
lab=#net16}
N 1665 -350 1665 -255 {
lab=#net16}
N 1390 -255 1665 -255 {
lab=#net16}
N 1375 -260 1645 -260 {
lab=#net15}
N 1375 -260 1375 -170 {
lab=#net15}
N 1375 -170 1385 -170 {
lab=#net15}
N 2240 -350 2270 -350 {
lab=#net17}
N 2270 -490 2270 -350 {
lab=#net17}
N 2040 -490 2270 -490 {
lab=#net17}
N 2040 -555 2040 -490 {
lab=#net17}
N 2040 -555 2085 -555 {
lab=#net17}
N 2240 -330 2255 -330 {
lab=#net18}
N 2255 -480 2255 -330 {
lab=#net18}
N 2080 -480 2255 -480 {
lab=#net18}
N 2080 -540 2080 -480 {
lab=#net18}
N 2255 -480 2370 -480 {
lab=#net18}
N 2370 -540 2370 -480 {
lab=#net18}
N 2270 -490 2360 -490 {
lab=#net17}
N 2360 -555 2360 -490 {
lab=#net17}
N 2360 -555 2370 -555 {
lab=#net17}
N 1690 -490 2040 -490 {
lab=#net17}
N 1690 -490 1690 -325 {
lab=#net17}
N 1690 -325 1730 -325 {
lab=#net17}
N 1675 -480 2080 -480 {
lab=#net18}
N 1675 -480 1675 -310 {
lab=#net18}
N 1675 -310 1730 -310 {
lab=#net18}
N 2315 -490 2315 -140 {
lab=#net17}
N 2315 -140 2360 -140 {
lab=#net17}
N 2340 -480 2340 -120 {
lab=#net18}
N 2340 -120 2360 -120 {
lab=#net18}
N 2830 -810 2930 -810 {
lab=#net19}
N 2830 -790 2930 -790 {
lab=#net20}
N 2870 -810 2870 -715 {
lab=#net19}
N 2595 -715 2870 -715 {
lab=#net19}
N 2595 -715 2595 -555 {
lab=#net19}
N 2595 -555 2650 -555 {
lab=#net19}
N 2855 -790 2855 -700 {
lab=#net20}
N 2615 -700 2855 -700 {
lab=#net20}
N 2615 -700 2615 -540 {
lab=#net20}
N 2615 -540 2650 -540 {
lab=#net20}
N 2595 -985 2595 -715 {
lab=#net19}
N 2595 -985 2670 -985 {
lab=#net19}
N 2615 -970 2615 -700 {
lab=#net20}
N 2615 -970 2670 -970 {
lab=#net20}
N 2325 -915 2595 -915 {
lab=#net19}
N 2325 -985 2325 -915 {
lab=#net19}
N 2325 -985 2370 -985 {
lab=#net19}
N 2340 -905 2615 -905 {
lab=#net20}
N 2340 -970 2340 -905 {
lab=#net20}
N 2340 -970 2370 -970 {
lab=#net20}
N 2830 -1380 2930 -1380 {
lab=#net21}
N 2830 -1360 2930 -1360 {
lab=#net22}
N 2855 -1480 2855 -1380 {
lab=#net21}
N 2335 -1480 2855 -1480 {
lab=#net21}
N 2335 -1535 2335 -1480 {
lab=#net21}
N 2335 -1535 2365 -1535 {
lab=#net21}
N 2365 -1535 2370 -1535 {
lab=#net21}
N 2845 -1470 2845 -1360 {
lab=#net22}
N 2345 -1470 2845 -1470 {
lab=#net22}
N 2345 -1520 2345 -1470 {
lab=#net22}
N 2345 -1520 2370 -1520 {
lab=#net22}
N 2335 -1480 2335 -1185 {
lab=#net21}
N 2335 -1185 2360 -1185 {
lab=#net21}
N 2345 -1470 2345 -1170 {
lab=#net22}
N 2345 -1170 2360 -1170 {
lab=#net22}
N 2335 -1355 2370 -1355 {
lab=#net21}
N 2345 -1340 2370 -1340 {
lab=#net22}
N 2250 -1770 2315 -1770 {
lab=#net23}
N 2315 -1970 2315 -1770 {
lab=#net23}
N 2315 -1970 2370 -1970 {
lab=#net23}
N 2250 -1750 2325 -1750 {
lab=#net24}
N 2325 -1950 2325 -1750 {
lab=#net24}
N 2325 -1950 2370 -1950 {
lab=#net24}
N 2270 -1770 2270 -1670 {
lab=#net23}
N 1665 -1670 2270 -1670 {
lab=#net23}
N 1665 -1670 1665 -1535 {
lab=#net23}
N 1665 -1535 1760 -1535 {
lab=#net23}
N 2290 -1750 2290 -1660 {
lab=#net24}
N 1690 -1660 2290 -1660 {
lab=#net24}
N 1690 -1660 1690 -1525 {
lab=#net24}
N 1690 -1525 1690 -1520 {
lab=#net24}
N 1690 -1520 1760 -1520 {
lab=#net24}
N 2060 -1670 2060 -1535 {
lab=#net23}
N 2060 -1535 2100 -1535 {
lab=#net23}
N 2075 -1660 2075 -1520 {
lab=#net24}
N 2075 -1520 2100 -1520 {
lab=#net24}
N 1665 -1740 1665 -1670 {
lab=#net23}
N 1665 -1745 1665 -1740 {
lab=#net23}
N 1665 -1745 1740 -1745 {
lab=#net23}
N 1690 -1730 1690 -1660 {
lab=#net24}
N 1690 -1730 1740 -1730 {
lab=#net24}
N 1410 -1770 1430 -1770 {
lab=#net7}
N 1425 -1750 1430 -1750 {
lab=#net8}
N 1375 -1770 1375 -1480 {
lab=#net7}
N 1375 -1770 1410 -1770 {
lab=#net7}
N 1385 -1750 1385 -1470 {
lab=#net8}
N 1385 -1750 1425 -1750 {
lab=#net8}
N 1600 -1770 1650 -1770 {
lab=#net25}
N 1650 -1880 1650 -1770 {
lab=#net25}
N 1375 -1880 1650 -1880 {
lab=#net25}
N 1375 -1970 1375 -1880 {
lab=#net25}
N 1375 -1970 1420 -1970 {
lab=#net25}
N 1600 -1750 1635 -1750 {
lab=#net26}
N 1635 -1870 1635 -1750 {
lab=#net26}
N 1400 -1870 1635 -1870 {
lab=#net26}
N 1400 -1950 1400 -1870 {
lab=#net26}
N 1400 -1950 1420 -1950 {
lab=#net26}
N 1405 -1535 1440 -1535 {
lab=#net25}
N 1405 -1880 1405 -1535 {
lab=#net25}
N 1415 -1870 1415 -1520 {
lab=#net26}
N 1415 -1520 1440 -1520 {
lab=#net26}
N 1120 -1680 1405 -1680 {
lab=#net25}
N 1120 -1680 1120 -1535 {
lab=#net25}
N 1120 -1535 1160 -1535 {
lab=#net25}
N 1130 -1665 1415 -1665 {
lab=#net26}
N 1130 -1665 1130 -1525 {
lab=#net26}
N 1130 -1525 1130 -1520 {
lab=#net26}
N 1130 -1520 1160 -1520 {
lab=#net26}
N 1120 -1745 1120 -1680 {
lab=#net25}
N 1120 -1745 1160 -1745 {
lab=#net25}
N 1130 -1730 1160 -1730 {
lab=#net26}
N 1130 -1730 1130 -1665 {
lab=#net26}
N 790 -1470 790 -1380 {
lab=#net27}
N 575 -1470 790 -1470 {
lab=#net27}
N 575 -1535 575 -1470 {
lab=#net27}
N 575 -1535 630 -1535 {
lab=#net27}
N 790 -1360 805 -1360 {
lab=#net28}
N 805 -1460 805 -1360 {
lab=#net28}
N 600 -1460 805 -1460 {
lab=#net28}
N 600 -1520 600 -1460 {
lab=#net28}
N 600 -1520 630 -1520 {
lab=#net28}
N 575 -1470 575 -1165 {
lab=#net27}
N 575 -1165 630 -1165 {
lab=#net27}
N 600 -1460 600 -1150 {
lab=#net28}
N 600 -1150 630 -1150 {
lab=#net28}
N 790 -1470 825 -1470 {
lab=#net27}
N 825 -1470 830 -1470 {
lab=#net27}
N 830 -1740 830 -1470 {
lab=#net27}
N 830 -1745 830 -1740 {
lab=#net27}
N 830 -1745 890 -1745 {
lab=#net27}
N 805 -1460 820 -1460 {
lab=#net28}
N 820 -1460 835 -1460 {
lab=#net28}
N 835 -1730 835 -1460 {
lab=#net28}
N 835 -1730 890 -1730 {
lab=#net28}
N 600 -1150 600 -970 {
lab=#net28}
N 600 -970 630 -970 {
lab=#net28}
N 575 -1165 575 -985 {
lab=#net27}
N 575 -985 630 -985 {
lab=#net27}
N 1570 -170 1645 -170 {
lab=#net29}
N 1645 -170 1645 -125 {
lab=#net29}
N 1645 -125 1720 -125 {
lab=#net29}
N 1570 -150 1625 -150 {
lab=#net30}
N 1625 -150 1625 -110 {
lab=#net30}
N 1625 -110 1720 -110 {
lab=#net30}
N 1645 -125 1645 -60 {
lab=#net29}
N 825 -60 1645 -60 {
lab=#net29}
N 820 -135 880 -135 {
lab=#net29}
N 820 -135 820 -60 {
lab=#net29}
N 820 -60 825 -60 {
lab=#net29}
N 1625 -110 1625 -80 {
lab=#net30}
N 850 -80 1625 -80 {
lab=#net30}
N 850 -120 850 -80 {
lab=#net30}
N 850 -120 880 -120 {
lab=#net30}
N 1075 -335 1075 -60 {
lab=#net29}
N 1075 -335 1150 -335 {
lab=#net29}
N 1100 -320 1100 -80 {
lab=#net30}
N 1100 -320 1150 -320 {
lab=#net30}
N 1100 -120 1150 -120 {
lab=#net30}
N 1075 -135 1150 -135 {
lab=#net29}
N 2530 -140 2565 -140 {
lab=#net31}
N 2565 -255 2565 -140 {
lab=#net31}
N 2350 -255 2565 -255 {
lab=#net31}
N 2350 -315 2350 -255 {
lab=#net31}
N 2350 -315 2370 -315 {
lab=#net31}
N 2370 -300 2370 -250 {
lab=#net32}
N 2370 -250 2555 -250 {
lab=#net32}
N 2555 -250 2555 -120 {
lab=#net32}
N 2530 -120 2555 -120 {
lab=#net32}
N 2565 -140 2595 -140 {
lab=#net31}
N 2595 -140 2595 -115 {
lab=#net31}
N 2595 -115 2650 -115 {
lab=#net31}
N 2555 -120 2555 -100 {
lab=#net32}
N 2555 -100 2650 -100 {
lab=#net32}
N 2565 -255 2625 -255 {
lab=#net31}
N 2625 -315 2625 -255 {
lab=#net31}
N 2625 -315 2650 -315 {
lab=#net31}
N 2555 -250 2650 -250 {
lab=#net32}
N 2650 -300 2650 -250 {
lab=#net32}
N 2565 -140 2565 -50 {
lab=#net31}
N 2025 -50 2565 -50 {
lab=#net31}
N 2025 -115 2025 -50 {
lab=#net31}
N 2025 -115 2070 -115 {
lab=#net31}
N 2555 -120 2555 -60 {
lab=#net32}
N 2070 -60 2555 -60 {
lab=#net32}
N 2070 -100 2070 -60 {
lab=#net32}
N 3100 -810 3145 -810 {
lab=#net33}
N 3145 -810 3145 -710 {
lab=#net33}
N 2895 -710 3145 -710 {
lab=#net33}
N 2875 -710 2895 -710 {
lab=#net33}
N 2875 -710 2875 -555 {
lab=#net33}
N 2875 -555 2920 -555 {
lab=#net33}
N 3100 -790 3120 -790 {
lab=#net34}
N 3120 -790 3120 -695 {
lab=#net34}
N 2900 -695 3120 -695 {
lab=#net34}
N 2900 -695 2900 -540 {
lab=#net34}
N 2900 -540 2920 -540 {
lab=#net34}
N 2875 -555 2875 -315 {
lab=#net33}
N 2875 -315 2920 -315 {
lab=#net33}
N 2900 -540 2900 -300 {
lab=#net34}
N 2900 -300 2920 -300 {
lab=#net34}
N 3145 -925 3145 -810 {
lab=#net33}
N 2895 -925 3145 -925 {
lab=#net33}
N 2895 -985 2895 -925 {
lab=#net33}
N 2895 -985 2940 -985 {
lab=#net33}
N 3120 -915 3120 -790 {
lab=#net34}
N 2935 -915 3120 -915 {
lab=#net34}
N 2935 -970 2935 -915 {
lab=#net34}
N 2935 -970 2940 -970 {
lab=#net34}
N 2895 -1185 2895 -985 {
lab=#net33}
N 2895 -1185 2930 -1185 {
lab=#net33}
N 2925 -970 2935 -970 {
lab=#net34}
N 2925 -1170 2925 -970 {
lab=#net34}
N 2925 -1170 2930 -1170 {
lab=#net34}
N 3100 -1380 3120 -1380 {
lab=#net35}
N 3120 -1470 3120 -1380 {
lab=#net35}
N 3120 -1485 3120 -1470 {
lab=#net35}
N 2600 -1485 3120 -1485 {
lab=#net35}
N 2600 -1535 2600 -1485 {
lab=#net35}
N 2600 -1535 2670 -1535 {
lab=#net35}
N 3100 -1360 3110 -1360 {
lab=#net36}
N 3110 -1465 3110 -1360 {
lab=#net36}
N 2670 -1465 3110 -1465 {
lab=#net36}
N 2670 -1520 2670 -1465 {
lab=#net36}
N 2895 -1535 2895 -1485 {
lab=#net35}
N 2895 -1535 2940 -1535 {
lab=#net35}
N 2915 -1520 2915 -1465 {
lab=#net36}
N 2915 -1520 2940 -1520 {
lab=#net36}
N 2895 -1745 2895 -1535 {
lab=#net35}
N 2895 -1745 2930 -1745 {
lab=#net35}
N 2915 -1730 2915 -1520 {
lab=#net36}
N 2915 -1730 2930 -1730 {
lab=#net36}
N 2600 -1485 2600 -1185 {
lab=#net35}
N 2600 -1185 2660 -1185 {
lab=#net35}
N 2625 -1465 2670 -1465 {
lab=#net36}
N 2625 -1465 2625 -1170 {
lab=#net36}
N 2625 -1170 2660 -1170 {
lab=#net36}
N 2540 -1970 2585 -1970 {
lab=#net37}
N 2585 -1970 2595 -1970 {
lab=#net37}
N 2595 -1970 2595 -1945 {
lab=#net37}
N 2595 -1945 2660 -1945 {
lab=#net37}
N 2540 -1950 2575 -1950 {
lab=#net38}
N 2575 -1950 2575 -1930 {
lab=#net38}
N 2575 -1930 2660 -1930 {
lab=#net38}
N 2605 -1945 2605 -1745 {
lab=#net37}
N 2605 -1745 2650 -1745 {
lab=#net37}
N 2615 -1930 2615 -1730 {
lab=#net38}
N 2615 -1730 2650 -1730 {
lab=#net38}
N 2345 -1880 2605 -1880 {
lab=#net37}
N 2345 -1880 2345 -1745 {
lab=#net37}
N 2345 -1745 2380 -1745 {
lab=#net37}
N 2355 -1860 2615 -1860 {
lab=#net38}
N 2355 -1860 2355 -1730 {
lab=#net38}
N 2355 -1730 2380 -1730 {
lab=#net38}
N 2605 -2100 2605 -1950 {
lab=#net37}
N 2025 -2100 2605 -2100 {
lab=#net37}
N 2025 -2100 2025 -1945 {
lab=#net37}
N 2025 -1945 2080 -1945 {
lab=#net37}
N 2615 -2085 2615 -1930 {
lab=#net38}
N 2045 -2085 2615 -2085 {
lab=#net38}
N 2045 -2085 2045 -1930 {
lab=#net38}
N 2045 -1930 2080 -1930 {
lab=#net38}
N 1590 -1970 1660 -1970 {
lab=#net39}
N 1660 -1970 1660 -1945 {
lab=#net39}
N 1660 -1945 1740 -1945 {
lab=#net39}
N 1590 -1950 1640 -1950 {
lab=#net40}
N 1640 -1950 1640 -1930 {
lab=#net40}
N 1640 -1930 1740 -1930 {
lab=#net40}
N 1630 -2090 1630 -1970 {
lab=#net39}
N 855 -2090 1630 -2090 {
lab=#net39}
N 825 -2090 855 -2090 {
lab=#net39}
N 825 -2090 825 -1945 {
lab=#net39}
N 825 -1945 890 -1945 {
lab=#net39}
N 1610 -2075 1610 -1950 {
lab=#net40}
N 865 -2075 1610 -2075 {
lab=#net40}
N 865 -2075 865 -1930 {
lab=#net40}
N 865 -1930 890 -1930 {
lab=#net40}
N 1135 -1945 1160 -1945 {
lab=#net39}
N 1135 -2090 1135 -1945 {
lab=#net39}
N 1125 -2075 1125 -1930 {
lab=#net40}
N 1125 -1930 1160 -1930 {
lab=#net40}
N 850 -190 880 -190 {
lab=VDD}
N 850 -230 850 -190 {
lab=VDD}
N 850 -230 980 -230 {
lab=VDD}
N 1150 -240 1150 -190 {
lab=VDD}
N 1720 -240 1720 -180 {
lab=VDD}
N 2070 -240 2070 -170 {
lab=VDD}
N 2650 -240 2650 -170 {
lab=VDD}
N 2920 -440 2920 -370 {
lab=VDD}
N 2650 -440 2650 -370 {
lab=VDD}
N 2370 -440 2370 -370 {
lab=VDD}
N 830 -170 880 -170 {
lab=R0D}
N 1120 -170 1150 -170 {
lab=R0D}
N 2620 -150 2650 -150 {
lab=R0D}
N 2890 -350 2920 -350 {
lab=R0D}
N 2880 -350 2890 -350 {
lab=R0D}
N 2610 -350 2650 -350 {
lab=R0D}
N 2320 -350 2370 -350 {
lab=R0D}
N 550 -390 610 -390 {
lab=R0D}
N 1090 -390 1150 -390 {
lab=R0D}
N 1680 -380 1730 -380 {
lab=R0D}
N 2040 -610 2080 -610 {
lab=R0D}
N 2320 -610 2370 -610 {
lab=R0D}
N 2600 -610 2650 -610 {
lab=R0D}
N 2880 -610 2920 -610 {
lab=R0D}
N 2880 -590 2920 -590 {
lab=R1D}
N 2600 -590 2650 -590 {
lab=R1D}
N 2320 -590 2370 -590 {
lab=R1D}
N 2040 -590 2080 -590 {
lab=R1D}
N 550 -370 610 -370 {
lab=R1D}
N 820 -370 880 -370 {
lab=R1D}
N 1090 -370 1150 -370 {
lab=R1D}
N 1680 -360 1730 -360 {
lab=R1D}
N 830 -150 880 -150 {
lab=C0D}
N 1120 -150 1150 -150 {
lab=C1D}
N 1680 -140 1720 -140 {
lab=C2D}
N 2030 -130 2070 -130 {
lab=C3D}
N 2620 -130 2650 -130 {
lab=C6D}
N 2320 -330 2370 -330 {
lab=C4D}
N 2600 -330 2650 -330 {
lab=C5D}
N 2880 -330 2920 -330 {
lab=VSS}
N 550 -350 610 -350 {
lab=C0D}
N 820 -350 880 -350 {
lab=C1D}
N 1100 -350 1150 -350 {
lab=C2D}
N 1680 -340 1730 -340 {
lab=C3D}
N 2040 -570 2080 -570 {
lab=C4D}
N 2320 -570 2370 -570 {
lab=C5D}
N 2600 -570 2650 -570 {
lab=C6D}
N 2880 -570 2920 -570 {
lab=VSS}
N 540 -610 610 -610 {
lab=R1D}
N 540 -590 610 -590 {
lab=R2D}
N 540 -570 610 -570 {
lab=C0D}
N 1110 -610 1150 -610 {
lab=R1D}
N 1110 -590 1150 -590 {
lab=R2D}
N 1110 -570 1150 -570 {
lab=C2D}
N 1360 -610 1410 -610 {
lab=R1D}
N 1360 -590 1410 -590 {
lab=R2D}
N 1360 -570 1410 -570 {
lab=C4D}
N 1405 -555 1410 -555 {
lab=#net15}
N 1685 -610 1740 -610 {
lab=R1D}
N 1690 -590 1740 -590 {
lab=R2D}
N 1690 -570 1740 -570 {
lab=C5D}
N 560 -840 630 -840 {
lab=R1D}
N 560 -820 630 -820 {
lab=R2D}
N 560 -800 630 -800 {
lab=C1D}
N 1105 -840 1170 -840 {
lab=R1D}
N 1105 -820 1170 -820 {
lab=R2D}
N 1105 -800 1170 -800 {
lab=C3D}
N 1705 -840 1760 -840 {
lab=R1D}
N 1705 -820 1760 -820 {
lab=R2D}
N 1710 -800 1760 -800 {
lab=C6D}
N 2320 -840 2380 -840 {
lab=R1D}
N 2325 -820 2380 -820 {
lab=R2D}
N 2325 -800 2380 -800 {
lab=VSS}
N 550 -1040 630 -1040 {
lab=R2D}
N 550 -1020 630 -1020 {
lab=R3D}
N 555 -1000 630 -1000 {
lab=C0D}
N 840 -1050 900 -1050 {
lab=R2D}
N 840 -1030 900 -1030 {
lab=R3D}
N 845 -1010 900 -1010 {
lab=C1D}
N 1105 -1050 1170 -1050 {
lab=R2D}
N 1105 -1030 1170 -1030 {
lab=R3D}
N 1110 -1010 1170 -1010 {
lab=C2D}
N 1380 -1040 1440 -1040 {
lab=R2D}
N 1380 -1020 1440 -1020 {
lab=R3D}
N 1385 -1000 1440 -1000 {
lab=C3D}
N 2055 -1040 2110 -1040 {
lab=R2D}
N 2055 -1020 2110 -1020 {
lab=R3D}
N 2060 -1000 2110 -1000 {
lab=C4D}
N 2315 -1040 2370 -1040 {
lab=R2D}
N 2315 -1020 2370 -1020 {
lab=R3D}
N 2315 -1000 2370 -1000 {
lab=C5D}
N 2600 -1040 2670 -1040 {
lab=R2D}
N 2600 -1020 2670 -1020 {
lab=R3D}
N 2605 -1000 2670 -1000 {
lab=C6D}
N 2870 -1040 2940 -1040 {
lab=R2D}
N 2875 -1020 2940 -1020 {
lab=R3D}
N 2875 -1000 2940 -1000 {
lab=VSS}
N 555 -1220 630 -1220 {
lab=R3D}
N 555 -1200 630 -1200 {
lab=R4D}
N 560 -1180 630 -1180 {
lab=C0D}
N 845 -1220 900 -1220 {
lab=R3D}
N 845 -1200 900 -1200 {
lab=R4D}
N 845 -1180 900 -1180 {
lab=C1D}
N 1095 -1230 1170 -1230 {
lab=R3D}
N 1100 -1210 1170 -1210 {
lab=R4D}
N 1100 -1190 1170 -1190 {
lab=C2D}
N 1375 -1240 1440 -1240 {
lab=R3D}
N 1380 -1220 1440 -1220 {
lab=R4D}
N 1380 -1200 1440 -1200 {
lab=C3D}
N 2040 -1240 2100 -1240 {
lab=R3D}
N 2040 -1220 2100 -1220 {
lab=R4D}
N 2045 -1200 2100 -1200 {
lab=C4D}
N 2300 -1240 2360 -1240 {
lab=R3D}
N 2305 -1220 2360 -1220 {
lab=R4D}
N 2305 -1200 2360 -1200 {
lab=C5D}
N 2610 -1240 2660 -1240 {
lab=R3D}
N 2610 -1220 2660 -1220 {
lab=R4D}
N 2610 -1200 2660 -1200 {
lab=C6D}
N 2870 -1240 2930 -1240 {
lab=R3D}
N 2870 -1220 2930 -1220 {
lab=R4D}
N 2875 -1200 2930 -1200 {
lab=VSS}
N 1110 -1410 1160 -1410 {
lab=R4D}
N 1110 -1390 1160 -1390 {
lab=R5D}
N 1120 -1370 1160 -1370 {
lab=C0D}
N 1715 -1410 1760 -1410 {
lab=R4D}
N 1710 -1390 1760 -1390 {
lab=R5D}
N 1720 -1370 1760 -1370 {
lab=C1D}
N 2315 -1410 2370 -1410 {
lab=R4D}
N 2315 -1390 2370 -1390 {
lab=R5D}
N 2315 -1370 2370 -1370 {
lab=C2D}
N 2605 -1590 2670 -1590 {
lab=R4D}
N 2605 -1570 2670 -1570 {
lab=R5D}
N 2605 -1550 2670 -1550 {
lab=C3D}
N 2875 -1590 2940 -1590 {
lab=R4D}
N 2875 -1570 2940 -1570 {
lab=R5D}
N 2880 -1550 2940 -1550 {
lab=C4D}
N 2600 -1800 2650 -1800 {
lab=R4D}
N 2600 -1780 2650 -1780 {
lab=R5D}
N 2600 -1760 2650 -1760 {
lab=C6D}
N 2870 -1800 2930 -1800 {
lab=R4D}
N 2880 -1780 2930 -1780 {
lab=R5D}
N 2875 -1760 2930 -1760 {
lab=C5D}
N 2620 -2000 2660 -2000 {
lab=R4D}
N 2620 -1980 2660 -1980 {
lab=R5D}
N 2620 -1960 2660 -1960 {
lab=VSS}
N 565 -1590 630 -1590 {
lab=R5D}
N 565 -1570 630 -1570 {
lab=R6D}
N 570 -1550 630 -1550 {
lab=C0D}
N 850 -1590 900 -1590 {
lab=R5D}
N 850 -1570 900 -1570 {
lab=R6D}
N 850 -1550 900 -1550 {
lab=C1D}
N 1110 -1590 1160 -1590 {
lab=R5D}
N 1105 -1570 1160 -1570 {
lab=R6D}
N 1105 -1550 1160 -1550 {
lab=C2D}
N 1395 -1590 1440 -1590 {
lab=R5D}
N 1395 -1570 1440 -1570 {
lab=R6D}
N 1395 -1550 1440 -1550 {
lab=C3D}
N 1710 -1590 1760 -1590 {
lab=R5D}
N 1710 -1570 1760 -1570 {
lab=R6D}
N 1715 -1550 1760 -1550 {
lab=C4D}
N 2065 -1590 2100 -1590 {
lab=R5D}
N 2065 -1570 2100 -1570 {
lab=R6D}
N 2070 -1550 2100 -1550 {
lab=C5D}
N 2315 -1590 2370 -1590 {
lab=R5D}
N 2320 -1570 2370 -1570 {
lab=R6D}
N 2320 -1550 2370 -1550 {
lab=C6D}
N 2330 -1800 2380 -1800 {
lab=R5D}
N 2335 -1780 2380 -1780 {
lab=R6D}
N 2335 -1760 2380 -1760 {
lab=VSS}
N 2335 -1760 2335 -1700 {
lab=VSS}
N 835 -1800 890 -1800 {
lab=R6D}
N 835 -1780 890 -1780 {
lab=VSS}
N 835 -1760 890 -1760 {
lab=C1D}
N 1100 -1800 1160 -1800 {
lab=R6D}
N 1100 -1780 1160 -1780 {
lab=VSS}
N 1100 -1760 1160 -1760 {
lab=C2D}
N 1680 -1800 1740 -1800 {
lab=R6D}
N 1680 -1780 1740 -1780 {
lab=VSS}
N 1680 -1760 1740 -1760 {
lab=C4D}
N 835 -2000 890 -2000 {
lab=R6D}
N 835 -1980 890 -1980 {
lab=VSS}
N 835 -1960 890 -1960 {
lab=C0D}
N 1100 -2000 1160 -2000 {
lab=R6D}
N 1105 -1980 1160 -1980 {
lab=VSS}
N 1105 -1960 1160 -1960 {
lab=C3D}
N 1695 -2000 1740 -2000 {
lab=R6D}
N 1695 -1980 1740 -1980 {
lab=VSS}
N 1695 -1960 1740 -1960 {
lab=C5D}
N 2035 -2000 2080 -2000 {
lab=R6D}
N 2035 -1980 2080 -1980 {
lab=VSS}
N 2035 -1960 2080 -1960 {
lab=C6D}
N 1810 -1265 1810 -1230 {
lab=SEL}
N 1675 -1200 1700 -1200 {
lab=B1D}
N 1670 -1180 1700 -1180 {
lab=B2D}
N 1675 -1160 1700 -1160 {
lab=B3D}
N 1675 -1140 1700 -1140 {
lab=B4D}
N 1675 -1120 1700 -1120 {
lab=B5D}
N 1675 -1100 1700 -1100 {
lab=B6D}
N 1680 -1080 1700 -1080 {
lab=ITAIL}
N 2000 -1160 2050 -1160 {
lab=OUT+}
N 2000 -1140 2050 -1140 {
lab=OUT-}
N 1620 -1255 1620 -1220 {
lab=OUT+}
N 1620 -1200 1620 -1165 {
lab=OUT-}
N 1620 -1050 1620 -1020 {
lab=OUT+}
N 1620 -1000 1620 -965 {
lab=OUT-}
N 1350 -1250 1350 -1210 {
lab=OUT+}
N 1350 -1190 1350 -1150 {
lab=OUT-}
N 1350 -1065 1350 -1030 {
lab=OUT+}
N 1350 -1010 1350 -985 {
lab=OUT-}
N 1080 -1075 1080 -1030 {
lab=OUT+}
N 1080 -1010 1080 -970 {
lab=OUT-}
N 810 -1065 810 -1020 {
lab=OUT+}
N 810 -1000 810 -965 {
lab=OUT-}
N 810 -860 810 -820 {
lab=OUT+}
N 810 -800 810 -760 {
lab=OUT-}
N 1350 -860 1350 -820 {
lab=OUT+}
N 1350 -800 1350 -760 {
lab=OUT-}
N 1940 -860 1940 -820 {
lab=OUT+}
N 1940 -800 1940 -760 {
lab=OUT-}
N 2560 -860 2560 -820 {
lab=OUT+}
N 2560 -800 2560 -760 {
lab=OUT-}
N 3100 -630 3100 -590 {
lab=OUT+}
N 3100 -570 3100 -530 {
lab=OUT-}
N 2830 -630 2830 -590 {
lab=OUT+}
N 2830 -570 2830 -530 {
lab=OUT-}
N 2550 -630 2550 -590 {
lab=OUT+}
N 2550 -570 2550 -530 {
lab=OUT-}
N 2260 -630 2260 -590 {
lab=OUT+}
N 2260 -570 2260 -530 {
lab=OUT-}
N 1920 -630 1920 -590 {
lab=OUT+}
N 1920 -570 1920 -530 {
lab=OUT-}
N 1590 -630 1590 -590 {
lab=OUT+}
N 1590 -570 1590 -530 {
lab=OUT-}
N 1330 -630 1330 -590 {
lab=OUT+}
N 1330 -570 1330 -530 {
lab=OUT-}
N 790 -630 790 -590 {
lab=OUT+}
N 790 -570 790 -530 {
lab=OUT-}
N 790 -410 790 -370 {
lab=OUT+}
N 790 -350 790 -310 {
lab=OUT-}
N 1060 -410 1060 -370 {
lab=OUT+}
N 1060 -350 1060 -310 {
lab=OUT-}
N 1330 -410 1330 -370 {
lab=OUT+}
N 1330 -350 1330 -310 {
lab=OUT-}
N 1910 -400 1910 -360 {
lab=OUT+}
N 1910 -340 1910 -300 {
lab=OUT-}
N 2550 -390 2550 -350 {
lab=OUT+}
N 2550 -330 2550 -290 {
lab=OUT-}
N 2830 -390 2830 -350 {
lab=OUT+}
N 2830 -330 2830 -290 {
lab=OUT-}
N 3100 -390 3100 -350 {
lab=OUT+}
N 3100 -330 3100 -290 {
lab=OUT-}
N 1060 -210 1060 -170 {
lab=OUT+}
N 1060 -150 1060 -110 {
lab=OUT-}
N 1330 -210 1330 -170 {
lab=OUT+}
N 1330 -150 1330 -110 {
lab=OUT-}
N 1900 -200 1900 -160 {
lab=OUT+}
N 1900 -140 1900 -100 {
lab=OUT-}
N 2250 -190 2250 -150 {
lab=OUT+}
N 2250 -130 2250 -90 {
lab=OUT-}
N 2830 -190 2830 -150 {
lab=OUT+}
N 2830 -130 2830 -90 {
lab=OUT-}
N 1070 -2020 1070 -1980 {
lab=OUT+}
N 1070 -1960 1070 -1920 {
lab=OUT-}
N 1340 -2020 1340 -1980 {
lab=OUT+}
N 1340 -1960 1340 -1920 {
lab=OUT-}
N 1920 -2020 1920 -1980 {
lab=OUT+}
N 1920 -1960 1920 -1920 {
lab=OUT-}
N 2260 -2020 2260 -1980 {
lab=OUT+}
N 2260 -1960 2260 -1920 {
lab=OUT-}
N 2840 -2020 2840 -1980 {
lab=OUT+}
N 2840 -1960 2840 -1920 {
lab=OUT-}
N 3110 -1820 3110 -1780 {
lab=OUT+}
N 3110 -1760 3110 -1720 {
lab=OUT-}
N 2830 -1820 2830 -1780 {
lab=OUT+}
N 2830 -1760 2830 -1720 {
lab=OUT-}
N 2560 -1820 2560 -1780 {
lab=OUT+}
N 2560 -1760 2560 -1720 {
lab=OUT-}
N 1920 -1820 1920 -1780 {
lab=OUT+}
N 1920 -1760 1920 -1720 {
lab=OUT-}
N 1340 -1820 1340 -1780 {
lab=OUT+}
N 1340 -1760 1340 -1720 {
lab=OUT-}
N 1070 -1820 1070 -1780 {
lab=OUT+}
N 1070 -1760 1070 -1720 {
lab=OUT-}
N 810 -1610 810 -1570 {
lab=OUT+}
N 810 -1550 810 -1510 {
lab=OUT-}
N 1080 -1610 1080 -1570 {
lab=OUT+}
N 1080 -1550 1080 -1510 {
lab=OUT-}
N 1340 -1610 1340 -1570 {
lab=OUT+}
N 1340 -1550 1340 -1510 {
lab=OUT-}
N 1620 -1610 1620 -1570 {
lab=OUT+}
N 1620 -1550 1620 -1510 {
lab=OUT-}
N 1940 -1610 1940 -1570 {
lab=OUT+}
N 1940 -1550 1940 -1510 {
lab=OUT-}
N 2280 -1610 2280 -1570 {
lab=OUT+}
N 2280 -1550 2280 -1510 {
lab=OUT-}
N 2550 -1610 2550 -1570 {
lab=OUT+}
N 2550 -1550 2550 -1510 {
lab=OUT-}
N 2850 -1610 2850 -1570 {
lab=OUT+}
N 2850 -1550 2850 -1510 {
lab=OUT-}
N 3120 -1610 3120 -1570 {
lab=OUT+}
N 3120 -1550 3120 -1510 {
lab=OUT-}
N 810 -1240 810 -1200 {
lab=OUT+}
N 810 -1180 810 -1140 {
lab=OUT-}
N 1080 -1240 1080 -1200 {
lab=OUT+}
N 1080 -1180 1080 -1140 {
lab=OUT-}
N 2540 -1255 2540 -1220 {
lab=OUT+}
N 2540 -1200 2540 -1165 {
lab=OUT-}
N 2840 -1255 2840 -1220 {
lab=OUT+}
N 2840 -1200 2840 -1165 {
lab=OUT-}
N 3110 -1255 3110 -1220 {
lab=OUT+}
N 3110 -1200 3110 -1165 {
lab=OUT-}
N 1340 -1425 1340 -1390 {
lab=OUT+}
N 1340 -1370 1340 -1335 {
lab=OUT-}
N 1940 -1425 1940 -1390 {
lab=OUT+}
N 1940 -1370 1940 -1335 {
lab=OUT-}
N 2550 -1425 2550 -1390 {
lab=OUT+}
N 2550 -1370 2550 -1335 {
lab=OUT-}
N 2030 -150 2070 -150 {
lab=R0D}
N 1685 -160 1720 -160 {
lab=R0D}
N 3585 -2120 3975 -2120 {
lab=VDD}
N 3585 -1940 3975 -1940 {
lab=VSS}
N 3435 -2050 3475 -2050 {
lab=B9D}
N 3435 -2030 3475 -2030 {
lab=B8D}
N 3435 -2010 3475 -2010 {
lab=B7D}
N 3825 -2050 3865 -2050 {
lab=B12D}
N 3825 -2030 3865 -2030 {
lab=B11D}
N 3825 -2010 3865 -2010 {
lab=B10D}
N 3705 -2090 3745 -2090 {
lab=C6}
N 3705 -2070 3745 -2070 {
lab=C5}
N 3705 -2050 3715 -2050 {
lab=C4}
N 3715 -2050 3745 -2050 {
lab=C4}
N 3705 -2030 3745 -2030 {
lab=C3}
N 3705 -2010 3745 -2010 {
lab=C2}
N 3705 -1970 3745 -1970 {
lab=C0}
N 4095 -2090 4135 -2090 {
lab=R6}
N 4095 -2070 4135 -2070 {
lab=R5}
N 4095 -2050 4105 -2050 {
lab=R4}
N 4105 -2050 4135 -2050 {
lab=R4}
N 4095 -2030 4135 -2030 {
lab=R3}
N 4095 -2010 4135 -2010 {
lab=R2}
N 4095 -1990 4135 -1990 {
lab=R1}
N 3705 -1990 3745 -1990 {
lab=C1}
N 4095 -1970 4135 -1970 {
lab=R0}
N 880 -420 880 -390 {
lab=R0D}
N 2280 -1255 2280 -1220 {
lab=OUT+}
N 2280 -1200 2280 -1165 {
lab=OUT-}
N 2290 -1055 2290 -1020 {
lab=OUT+}
N 2290 -1000 2290 -965 {
lab=OUT-}
N 2550 -1055 2550 -1020 {
lab=OUT+}
N 2550 -1000 2550 -965 {
lab=OUT-}
N 2850 -1055 2850 -1020 {
lab=OUT+}
N 2850 -1000 2850 -965 {
lab=OUT-}
N 3120 -1055 3120 -1020 {
lab=OUT+}
N 3120 -1000 3120 -965 {
lab=OUT-}
N 1060 -210 1330 -210 {
lab=OUT+}
N 1060 -110 1060 -100 {
lab=OUT-}
N 1060 -100 1330 -100 {
lab=OUT-}
N 1330 -110 1330 -100 {
lab=OUT-}
N 1350 -980 1350 -960 {
lab=OUT-}
N 1350 -985 1350 -980 {
lab=OUT-}
N 2605 -1950 2605 -1945 {
lab=#net37}
N 3340 -550 3430 -550 {
lab=B1}
N 3470 -640 3470 -610 {
lab=VDD}
N 3470 -640 3705 -640 {
lab=VDD}
N 3705 -640 3705 -610 {
lab=VDD}
N 3470 -490 3470 -470 {
lab=VSS}
N 3470 -470 3705 -470 {
lab=VSS}
N 3705 -490 3705 -470 {
lab=VSS}
N 3805 -550 3875 -550 {
lab=B1D}
N 3340 -800 3430 -800 {
lab=B2}
N 3470 -890 3470 -860 {
lab=VDD}
N 3470 -890 3705 -890 {
lab=VDD}
N 3705 -890 3705 -860 {
lab=VDD}
N 3470 -740 3470 -720 {
lab=VSS}
N 3470 -720 3705 -720 {
lab=VSS}
N 3705 -740 3705 -720 {
lab=VSS}
N 3805 -800 3875 -800 {
lab=B2D}
N 4005 -550 4095 -550 {
lab=B4}
N 4135 -640 4135 -610 {
lab=VDD}
N 4135 -640 4370 -640 {
lab=VDD}
N 4370 -640 4370 -610 {
lab=VDD}
N 4135 -490 4135 -470 {
lab=VSS}
N 4135 -470 4370 -470 {
lab=VSS}
N 4370 -490 4370 -470 {
lab=VSS}
N 4470 -550 4540 -550 {
lab=B4D}
N 4000 -805 4090 -805 {
lab=B3}
N 4130 -895 4130 -865 {
lab=VDD}
N 4130 -895 4365 -895 {
lab=VDD}
N 4365 -895 4365 -865 {
lab=VDD}
N 4130 -745 4130 -725 {
lab=VSS}
N 4130 -725 4365 -725 {
lab=VSS}
N 4365 -745 4365 -725 {
lab=VSS}
N 4465 -805 4535 -805 {
lab=B3D}
N 4705 -805 4795 -805 {
lab=B5}
N 4835 -895 4835 -865 {
lab=VDD}
N 4835 -895 5070 -895 {
lab=VDD}
N 5070 -895 5070 -865 {
lab=VDD}
N 4835 -745 4835 -725 {
lab=VSS}
N 4835 -725 5070 -725 {
lab=VSS}
N 5070 -745 5070 -725 {
lab=VSS}
N 5170 -805 5240 -805 {
lab=B5D}
N 4715 -555 4805 -555 {
lab=B6}
N 4845 -645 4845 -615 {
lab=VDD}
N 4845 -645 5080 -645 {
lab=VDD}
N 5080 -645 5080 -615 {
lab=VDD}
N 4845 -495 4845 -475 {
lab=VSS}
N 4845 -475 5080 -475 {
lab=VSS}
N 5080 -495 5080 -475 {
lab=VSS}
N 5180 -555 5250 -555 {
lab=B6D}
N 3325 -1120 3415 -1120 {
lab=B7}
N 3455 -1210 3455 -1180 {
lab=VDD}
N 3455 -1210 3690 -1210 {
lab=VDD}
N 3690 -1210 3690 -1180 {
lab=VDD}
N 3455 -1060 3455 -1040 {
lab=VSS}
N 3455 -1040 3690 -1040 {
lab=VSS}
N 3690 -1060 3690 -1040 {
lab=VSS}
N 3790 -1120 3860 -1120 {
lab=B7D}
N 3325 -1370 3415 -1370 {
lab=B10}
N 3455 -1460 3455 -1430 {
lab=VDD}
N 3455 -1460 3690 -1460 {
lab=VDD}
N 3690 -1460 3690 -1430 {
lab=VDD}
N 3455 -1310 3455 -1290 {
lab=VSS}
N 3455 -1290 3690 -1290 {
lab=VSS}
N 3690 -1310 3690 -1290 {
lab=VSS}
N 3790 -1370 3860 -1370 {
lab=B10D}
N 3990 -1120 4080 -1120 {
lab=B8}
N 4120 -1210 4120 -1180 {
lab=VDD}
N 4120 -1210 4355 -1210 {
lab=VDD}
N 4355 -1210 4355 -1180 {
lab=VDD}
N 4120 -1060 4120 -1040 {
lab=VSS}
N 4120 -1040 4355 -1040 {
lab=VSS}
N 4355 -1060 4355 -1040 {
lab=VSS}
N 4455 -1120 4525 -1120 {
lab=B8D}
N 3985 -1375 4075 -1375 {
lab=B11}
N 4115 -1465 4115 -1435 {
lab=VDD}
N 4115 -1465 4350 -1465 {
lab=VDD}
N 4350 -1465 4350 -1435 {
lab=VDD}
N 4115 -1315 4115 -1295 {
lab=VSS}
N 4115 -1295 4350 -1295 {
lab=VSS}
N 4350 -1315 4350 -1295 {
lab=VSS}
N 4450 -1375 4520 -1375 {
lab=B11D}
N 4690 -1375 4780 -1375 {
lab=B12}
N 4820 -1465 4820 -1435 {
lab=VDD}
N 4820 -1465 5055 -1465 {
lab=VDD}
N 5055 -1465 5055 -1435 {
lab=VDD}
N 4820 -1315 4820 -1295 {
lab=VSS}
N 4820 -1295 5055 -1295 {
lab=VSS}
N 5055 -1315 5055 -1295 {
lab=VSS}
N 5155 -1375 5225 -1375 {
lab=B12D}
N 4700 -1125 4790 -1125 {
lab=B9}
N 4830 -1215 4830 -1185 {
lab=VDD}
N 4830 -1215 5065 -1215 {
lab=VDD}
N 5065 -1215 5065 -1185 {
lab=VDD}
N 4830 -1065 4830 -1045 {
lab=VSS}
N 4830 -1045 5065 -1045 {
lab=VSS}
N 5065 -1065 5065 -1045 {
lab=VSS}
N 5165 -1125 5235 -1125 {
lab=B9D}
N 3540 -1740 3630 -1740 {
lab=SEL_L}
N 3670 -1830 3670 -1800 {
lab=VDD}
N 3670 -1830 3905 -1830 {
lab=VDD}
N 3905 -1830 3905 -1800 {
lab=VDD}
N 3670 -1680 3670 -1660 {
lab=VSS}
N 3670 -1660 3905 -1660 {
lab=VSS}
N 3905 -1680 3905 -1660 {
lab=VSS}
N 4005 -1740 4075 -1740 {
lab=SEL}
N 4290 -2540 4290 -2490 {
lab=VDD}
N 4240 -2460 4270 -2460 {
lab=VDD}
N 4290 -2430 4290 -2360 {
lab=OUT-}
N 4290 -2540 4290 -2490 {
lab=VDD}
N 4240 -2460 4270 -2460 {
lab=VDD}
N 4290 -2430 4290 -2360 {
lab=OUT-}
N 4500 -2540 4500 -2490 {
lab=VDD}
N 4450 -2460 4480 -2460 {
lab=VDD}
N 4500 -2430 4500 -2360 {
lab=OUT+}
N 4500 -2540 4500 -2490 {
lab=VDD}
N 4450 -2460 4480 -2460 {
lab=VDD}
N 4500 -2430 4500 -2360 {
lab=OUT+}
N 4290 -2580 4290 -2540 {
lab=VDD}
N 4500 -2570 4500 -2540 {
lab=VDD}
N 4290 -2580 4500 -2580 {
lab=VDD}
N 4500 -2580 4500 -2570 {
lab=VDD}
N 4680 -2540 4680 -2490 {
lab=VDD}
N 4680 -2430 4680 -2360 {
lab=OUT+}
N 4680 -2540 4680 -2490 {
lab=VDD}
N 4680 -2430 4680 -2360 {
lab=OUT+}
N 4680 -2570 4680 -2540 {
lab=VDD}
N 4680 -2580 4680 -2570 {
lab=VDD}
N 4860 -2540 4860 -2490 {
lab=VDD}
N 4860 -2430 4860 -2360 {
lab=OUT+}
N 4860 -2540 4860 -2490 {
lab=VDD}
N 4860 -2430 4860 -2360 {
lab=OUT+}
N 4860 -2570 4860 -2540 {
lab=VDD}
N 4860 -2580 4860 -2570 {
lab=VDD}
N 5030 -2540 5030 -2490 {
lab=VDD}
N 5030 -2430 5030 -2360 {
lab=OUT+}
N 5030 -2540 5030 -2490 {
lab=VDD}
N 5030 -2430 5030 -2360 {
lab=OUT+}
N 5030 -2570 5030 -2540 {
lab=VDD}
N 5030 -2580 5030 -2570 {
lab=VDD}
N 5180 -2540 5180 -2490 {
lab=VDD}
N 5180 -2430 5180 -2360 {
lab=OUT+}
N 5180 -2540 5180 -2490 {
lab=VDD}
N 5180 -2430 5180 -2360 {
lab=OUT+}
N 5180 -2570 5180 -2540 {
lab=VDD}
N 5180 -2580 5180 -2570 {
lab=VDD}
N 5330 -2540 5330 -2490 {
lab=VDD}
N 5330 -2430 5330 -2360 {
lab=OUT+}
N 5330 -2540 5330 -2490 {
lab=VDD}
N 5330 -2430 5330 -2360 {
lab=OUT+}
N 5330 -2570 5330 -2540 {
lab=VDD}
N 5330 -2580 5330 -2570 {
lab=VDD}
N 5480 -2550 5480 -2500 {
lab=VDD}
N 5480 -2440 5480 -2370 {
lab=OUT+}
N 5480 -2550 5480 -2500 {
lab=VDD}
N 5480 -2440 5480 -2370 {
lab=OUT+}
N 5480 -2580 5480 -2550 {
lab=VDD}
N 5640 -2550 5640 -2500 {
lab=VDD}
N 5640 -2440 5640 -2370 {
lab=OUT+}
N 5640 -2550 5640 -2500 {
lab=VDD}
N 5640 -2440 5640 -2370 {
lab=OUT+}
N 5640 -2580 5640 -2550 {
lab=VDD}
N 5800 -2550 5800 -2500 {
lab=VDD}
N 5800 -2440 5800 -2370 {
lab=OUT+}
N 5800 -2550 5800 -2500 {
lab=VDD}
N 5800 -2440 5800 -2370 {
lab=OUT+}
N 5800 -2580 5800 -2550 {
lab=VDD}
N 5960 -2550 5960 -2500 {
lab=VDD}
N 5960 -2440 5960 -2370 {
lab=OUT+}
N 5960 -2550 5960 -2500 {
lab=VDD}
N 5960 -2440 5960 -2370 {
lab=OUT+}
N 5960 -2580 5960 -2550 {
lab=VDD}
N 4500 -2580 5800 -2580 {
lab=VDD}
N 5800 -2580 5960 -2580 {
lab=VDD}
N 4500 -2360 5960 -2360 {
lab=OUT+}
N 5960 -2370 5960 -2360 {
lab=OUT+}
N 5800 -2370 5800 -2360 {
lab=OUT+}
N 5640 -2370 5640 -2360 {
lab=OUT+}
N 5480 -2370 5480 -2360 {
lab=OUT+}
N 2820 -2540 2820 -2490 {
lab=VDD}
N 2820 -2430 2820 -2360 {
lab=OUT-}
N 2820 -2540 2820 -2490 {
lab=VDD}
N 2820 -2430 2820 -2360 {
lab=OUT-}
N 2820 -2570 2820 -2540 {
lab=VDD}
N 2820 -2580 2820 -2570 {
lab=VDD}
N 3000 -2540 3000 -2490 {
lab=VDD}
N 3000 -2430 3000 -2360 {
lab=OUT-}
N 3000 -2540 3000 -2490 {
lab=VDD}
N 3000 -2430 3000 -2360 {
lab=OUT-}
N 3000 -2570 3000 -2540 {
lab=VDD}
N 3000 -2580 3000 -2570 {
lab=VDD}
N 3170 -2540 3170 -2490 {
lab=VDD}
N 3170 -2430 3170 -2360 {
lab=OUT-}
N 3170 -2540 3170 -2490 {
lab=VDD}
N 3170 -2430 3170 -2360 {
lab=OUT-}
N 3170 -2570 3170 -2540 {
lab=VDD}
N 3170 -2580 3170 -2570 {
lab=VDD}
N 3320 -2540 3320 -2490 {
lab=VDD}
N 3320 -2430 3320 -2360 {
lab=OUT-}
N 3320 -2540 3320 -2490 {
lab=VDD}
N 3320 -2430 3320 -2360 {
lab=OUT-}
N 3320 -2570 3320 -2540 {
lab=VDD}
N 3320 -2580 3320 -2570 {
lab=VDD}
N 3470 -2540 3470 -2490 {
lab=VDD}
N 3470 -2430 3470 -2360 {
lab=OUT-}
N 3470 -2540 3470 -2490 {
lab=VDD}
N 3470 -2430 3470 -2360 {
lab=OUT-}
N 3470 -2570 3470 -2540 {
lab=VDD}
N 3470 -2580 3470 -2570 {
lab=VDD}
N 3620 -2550 3620 -2500 {
lab=VDD}
N 3620 -2440 3620 -2370 {
lab=OUT-}
N 3620 -2550 3620 -2500 {
lab=VDD}
N 3620 -2440 3620 -2370 {
lab=OUT-}
N 3620 -2580 3620 -2550 {
lab=VDD}
N 3780 -2550 3780 -2500 {
lab=VDD}
N 3780 -2440 3780 -2370 {
lab=OUT-}
N 3780 -2550 3780 -2500 {
lab=VDD}
N 3780 -2440 3780 -2370 {
lab=OUT-}
N 3780 -2580 3780 -2550 {
lab=VDD}
N 3940 -2550 3940 -2500 {
lab=VDD}
N 3940 -2440 3940 -2370 {
lab=OUT-}
N 3940 -2550 3940 -2500 {
lab=VDD}
N 3940 -2440 3940 -2370 {
lab=OUT-}
N 3940 -2580 3940 -2550 {
lab=VDD}
N 4100 -2550 4100 -2500 {
lab=VDD}
N 4100 -2440 4100 -2370 {
lab=OUT-}
N 4100 -2550 4100 -2500 {
lab=VDD}
N 4100 -2440 4100 -2370 {
lab=OUT-}
N 4100 -2580 4100 -2550 {
lab=VDD}
N 3940 -2580 4100 -2580 {
lab=VDD}
N 4100 -2370 4100 -2360 {
lab=OUT-}
N 3940 -2370 3940 -2360 {
lab=OUT-}
N 3780 -2370 3780 -2360 {
lab=OUT-}
N 3620 -2370 3620 -2360 {
lab=OUT-}
N 2820 -2580 3940 -2580 {
lab=VDD}
N 2820 -2360 4290 -2360 {
lab=OUT-}
N 4090 -2580 4300 -2580 {
lab=VDD}
N 2690 -2540 2690 -2490 {
lab=#net41}
N 2690 -2430 2690 -2360 {
lab=#net42}
N 2540 -2540 2540 -2490 {
lab=#net43}
N 2540 -2430 2540 -2360 {
lab=#net44}
N 2370 -2540 2370 -2490 {
lab=#net45}
N 2370 -2430 2370 -2360 {
lab=#net46}
N 2190 -2540 2190 -2490 {
lab=#net47}
N 2190 -2430 2190 -2360 {
lab=#net48}
N 2960 -2460 2980 -2460 {
lab=VDD}
N 2960 -2580 2960 -2460 {
lab=VDD}
N 3130 -2460 3150 -2460 {
lab=VDD}
N 3130 -2580 3130 -2460 {
lab=VDD}
N 3280 -2460 3300 -2460 {
lab=VDD}
N 3280 -2580 3280 -2460 {
lab=VDD}
N 3430 -2460 3450 -2460 {
lab=VDD}
N 3430 -2580 3430 -2460 {
lab=VDD}
N 3580 -2470 3600 -2470 {
lab=VDD}
N 3580 -2580 3580 -2470 {
lab=VDD}
N 3730 -2470 3760 -2470 {
lab=VDD}
N 3730 -2580 3730 -2470 {
lab=VDD}
N 3880 -2470 3920 -2470 {
lab=VDD}
N 3880 -2580 3880 -2470 {
lab=VDD}
N 4040 -2470 4080 -2470 {
lab=VDD}
N 4040 -2580 4040 -2470 {
lab=VDD}
N 4240 -2580 4240 -2460 {
lab=VDD}
N 4450 -2580 4450 -2460 {
lab=VDD}
N 4630 -2460 4660 -2460 {
lab=VDD}
N 4630 -2580 4630 -2460 {
lab=VDD}
N 4810 -2460 4840 -2460 {
lab=VDD}
N 4810 -2580 4810 -2460 {
lab=VDD}
N 4980 -2460 5010 -2460 {
lab=VDD}
N 4980 -2580 4980 -2460 {
lab=VDD}
N 5120 -2460 5160 -2460 {
lab=VDD}
N 5120 -2580 5120 -2460 {
lab=VDD}
N 5270 -2460 5310 -2460 {
lab=VDD}
N 5270 -2580 5270 -2460 {
lab=VDD}
N 5410 -2470 5460 -2470 {
lab=VDD}
N 5410 -2580 5410 -2470 {
lab=VDD}
N 5580 -2470 5620 -2470 {
lab=VDD}
N 5580 -2580 5580 -2470 {
lab=VDD}
N 5740 -2470 5780 -2470 {
lab=VDD}
N 5740 -2580 5740 -2470 {
lab=VDD}
N 5890 -2470 5940 -2470 {
lab=VDD}
N 5890 -2580 5890 -2470 {
lab=VDD}
N 2310 -2460 2350 -2460 {
lab=VDD}
N 2490 -2460 2520 -2460 {
lab=VDD}
N 2630 -2460 2670 -2460 {
lab=VDD}
N 2770 -2460 2800 -2460 {
lab=VDD}
N 5670 -2030 5670 -1985 {
lab=VDD}
N 5670 -2030 6035 -2030 {
lab=VDD}
N 6035 -2030 6035 -1990 {
lab=VDD}
N 5670 -1870 5670 -1835 {
lab=VSS}
N 5670 -1835 6035 -1835 {
lab=VSS}
N 6035 -1870 6035 -1835 {
lab=VSS}
N 5670 -1780 6035 -1780 {
lab=VDD}
N 5665 -1660 6035 -1660 {
lab=VSS}
N 5660 -1545 6040 -1545 {
lab=VDD}
N 6040 -1545 6040 -1540 {
lab=VDD}
N 5660 -1420 6040 -1420 {
lab=VSS}
N 5670 -1360 5670 -1345 {
lab=VDD}
N 5670 -1360 6040 -1360 {
lab=VDD}
N 6040 -1360 6040 -1350 {
lab=VDD}
N 5670 -1225 6040 -1225 {
lab=VSS}
N 6040 -1230 6040 -1225 {
lab=VSS}
N 5670 -1155 5670 -1135 {
lab=VDD}
N 5670 -1155 6040 -1155 {
lab=VDD}
N 6040 -1155 6040 -1135 {
lab=VDD}
N 5670 -1015 5670 -1000 {
lab=VSS}
N 5670 -1000 6040 -1000 {
lab=VSS}
N 6040 -1015 6040 -1000 {
lab=VSS}
N 5665 -940 6035 -940 {
lab=VDD}
N 6035 -940 6035 -935 {
lab=VDD}
N 5665 -820 5665 -805 {
lab=VSS}
N 5665 -805 6035 -805 {
lab=VSS}
N 6035 -815 6035 -805 {
lab=VSS}
N 5660 -735 5660 -720 {
lab=VDD}
N 5660 -735 6030 -735 {
lab=VDD}
N 6030 -735 6030 -720 {
lab=VDD}
N 5660 -600 5660 -585 {
lab=VSS}
N 5660 -585 6030 -585 {
lab=VSS}
N 6030 -600 6030 -585 {
lab=VSS}
N 5565 -1930 5630 -1930 {
lab=R0}
N 5770 -1930 5995 -1930 {
lab=R0m}
N 5770 -1720 5995 -1720 {
lab=R1m}
N 5765 -1480 6000 -1480 {
lab=R2m}
N 5770 -1285 6000 -1285 {
lab=R3m}
N 6000 -1290 6000 -1285 {
lab=R3m}
N 5770 -1075 6000 -1075 {
lab=R4m}
N 5765 -880 5995 -880 {
lab=R5m}
N 5995 -880 5995 -875 {
lab=R5m}
N 5760 -660 5990 -660 {
lab=R6m}
N 5565 -1720 5630 -1720 {
lab=R1}
N 6135 -1720 6215 -1720 {
lab=R1D}
N 6135 -1930 6215 -1930 {
lab=R0D}
N 6140 -1480 6220 -1480 {
lab=R2D}
N 6140 -1290 6220 -1290 {
lab=R3D}
N 6140 -1075 6220 -1075 {
lab=R4D}
N 6135 -875 6215 -875 {
lab=R5D}
N 6130 -660 6210 -660 {
lab=R6D}
N 5540 -660 5620 -660 {
lab=R6}
N 5545 -880 5625 -880 {
lab=R5}
N 5550 -1075 5630 -1075 {
lab=R4}
N 5555 -1285 5635 -1285 {
lab=R3}
N 5550 -1480 5630 -1480 {
lab=R2}
N 6685 -2045 6685 -2000 {
lab=VDD}
N 6685 -2045 7050 -2045 {
lab=VDD}
N 7050 -2045 7050 -2005 {
lab=VDD}
N 6685 -1885 6685 -1850 {
lab=VSS}
N 6685 -1850 7050 -1850 {
lab=VSS}
N 7050 -1885 7050 -1850 {
lab=VSS}
N 6685 -1795 7050 -1795 {
lab=VDD}
N 6680 -1675 7050 -1675 {
lab=VSS}
N 6675 -1560 7055 -1560 {
lab=VDD}
N 7055 -1560 7055 -1555 {
lab=VDD}
N 6675 -1435 7055 -1435 {
lab=VSS}
N 6685 -1375 6685 -1360 {
lab=VDD}
N 6685 -1375 7055 -1375 {
lab=VDD}
N 7055 -1375 7055 -1365 {
lab=VDD}
N 6685 -1240 7055 -1240 {
lab=VSS}
N 7055 -1245 7055 -1240 {
lab=VSS}
N 6685 -1170 6685 -1150 {
lab=VDD}
N 6685 -1170 7055 -1170 {
lab=VDD}
N 7055 -1170 7055 -1150 {
lab=VDD}
N 6685 -1030 6685 -1015 {
lab=VSS}
N 6685 -1015 7055 -1015 {
lab=VSS}
N 7055 -1030 7055 -1015 {
lab=VSS}
N 6680 -955 7050 -955 {
lab=VDD}
N 7050 -955 7050 -950 {
lab=VDD}
N 6680 -835 6680 -820 {
lab=VSS}
N 6680 -820 7050 -820 {
lab=VSS}
N 7050 -830 7050 -820 {
lab=VSS}
N 6675 -750 6675 -735 {
lab=VDD}
N 6675 -750 7045 -750 {
lab=VDD}
N 7045 -750 7045 -735 {
lab=VDD}
N 6675 -615 6675 -600 {
lab=VSS}
N 6675 -600 7045 -600 {
lab=VSS}
N 7045 -615 7045 -600 {
lab=VSS}
N 6580 -1945 6645 -1945 {
lab=C0}
N 6785 -1945 7010 -1945 {
lab=C0M}
N 6785 -1735 7010 -1735 {
lab=C1M}
N 6780 -1495 7015 -1495 {
lab=C2M}
N 6785 -1300 7015 -1300 {
lab=C3M}
N 7015 -1305 7015 -1300 {
lab=C3M}
N 6785 -1090 7015 -1090 {
lab=C4M}
N 6780 -895 7010 -895 {
lab=C5M}
N 7010 -895 7010 -890 {
lab=C5M}
N 6775 -675 7005 -675 {
lab=C6M}
N 6580 -1735 6645 -1735 {
lab=C1}
N 7150 -1735 7230 -1735 {
lab=C1D}
N 7150 -1945 7230 -1945 {
lab=C0D}
N 7155 -1495 7235 -1495 {
lab=C2D}
N 7155 -1305 7235 -1305 {
lab=C3D}
N 7155 -1090 7235 -1090 {
lab=C4D}
N 7150 -890 7230 -890 {
lab=C5D}
N 7145 -675 7225 -675 {
lab=C6D}
N 6555 -675 6635 -675 {
lab=C6}
N 6560 -895 6640 -895 {
lab=C5}
N 6565 -1090 6645 -1090 {
lab=C4}
N 6570 -1300 6650 -1300 {
lab=C3}
N 6565 -1495 6645 -1495 {
lab=C2}
N 2770 -2580 2770 -2460 {
lab=VDD}
N 2770 -2580 2820 -2580 {
lab=VDD}
N 2140 -2460 2170 -2460 {
lab=VDD}
N 2140 -2575 2140 -2460 {
lab=VDD}
N 2140 -2585 2140 -2575 {
lab=VDD}
N 2310 -2585 2310 -2460 {
lab=VDD}
N 2490 -2585 2490 -2460 {
lab=VDD}
N 2630 -2585 2630 -2460 {
lab=VDD}
N 2140 -2585 2145 -2585 {
lab=VDD}
N 2145 -2585 2310 -2585 {
lab=VDD}
N 2630 -2580 2770 -2580 {
lab=VDD}
N 2310 -2585 2630 -2585 {
lab=VDD}
N 3570 -800 3665 -800 {
lab=B2M}
N 3570 -550 3665 -550 {
lab=B1M}
N 4230 -805 4325 -805 {
lab=B3M}
N 4235 -550 4330 -550 {
lab=B4M}
N 4935 -805 5030 -805 {
lab=B5M}
N 4945 -555 5040 -555 {
lab=B6M}
N 3555 -1370 3650 -1370 {
lab=B10M}
N 3555 -1120 3650 -1120 {
lab=B7M}
N 4220 -1120 4315 -1120 {
lab=B8M}
N 4215 -1375 4310 -1375 {
lab=B11M}
N 4920 -1375 5015 -1375 {
lab=B12M}
N 4930 -1125 5025 -1125 {
lab=B9M}
N 3770 -1740 3865 -1740 {
lab=#net49}
C {CM_LSB_s.sym} 1850 -1130 0 0 {name=x1}
C {MSB_UNIT_CELL.sym} 1800 -1370 0 0 {name=x2}
C {MSB_UNIT_CELL.sym} 2140 -1200 0 0 {name=x3}
C {MSB_UNIT_CELL.sym} 2150 -1000 0 0 {name=x4}
C {MSB_UNIT_CELL.sym} 1480 -1200 0 0 {name=x5}
C {MSB_UNIT_CELL.sym} 1480 -1000 0 0 {name=x6}
C {MSB_UNIT_CELL.sym} 1800 -800 0 0 {name=x7}
C {CM_32_s.sym} 2190 -1370 0 0 {name=x8}
C {CM_32_s.sym} 1530 -1370 0 0 {name=x9}
C {CM_32_s.sym} 2200 -800 0 0 {name=x10}
C {CM_32_s.sym} 1530 -800 0 0 {name=x11}
C {MSB_UNIT_CELL.sym} 1480 -1550 0 0 {name=x12}
C {MSB_UNIT_CELL.sym} 1800 -1550 0 0 {name=x13}
C {MSB_UNIT_CELL.sym} 2140 -1550 0 0 {name=x14}
C {MSB_UNIT_CELL.sym} 1200 -1550 0 0 {name=x15}
C {MSB_UNIT_CELL.sym} 2410 -1550 0 0 {name=x16}
C {MSB_UNIT_CELL.sym} 1200 -1370 0 0 {name=x17}
C {MSB_UNIT_CELL.sym} 1210 -1190 0 0 {name=x18}
C {MSB_UNIT_CELL.sym} 1210 -1010 0 0 {name=x19}
C {MSB_UNIT_CELL.sym} 1210 -800 0 0 {name=x20}
C {MSB_UNIT_CELL.sym} 1190 -570 0 0 {name=x21}
C {MSB_UNIT_CELL.sym} 1450 -570 0 0 {name=x22}
C {MSB_UNIT_CELL.sym} 1780 -570 0 0 {name=x23}
C {MSB_UNIT_CELL.sym} 2120 -570 0 0 {name=x24}
C {MSB_UNIT_CELL.sym} 2410 -570 0 0 {name=x25}
C {MSB_UNIT_CELL.sym} 2420 -800 0 0 {name=x26}
C {MSB_UNIT_CELL.sym} 2410 -1000 0 0 {name=x27}
C {MSB_UNIT_CELL.sym} 2400 -1200 0 0 {name=x28}
C {MSB_UNIT_CELL.sym} 2410 -1370 0 0 {name=x29}
C {MSB_UNIT_CELL.sym} 940 -1550 0 0 {name=x30}
C {CM_32_s.sym} 990 -1370 0 0 {name=x31}
C {MSB_UNIT_CELL.sym} 940 -1180 0 0 {name=x32}
C {MSB_UNIT_CELL.sym} 940 -1010 0 0 {name=x35}
C {CM_32_s.sym} 990 -580 0 0 {name=x33}
C {CM_32_s.sym} 990 -800 0 0 {name=x34}
C {MSB_UNIT_CELL.sym} 670 -1550 0 0 {name=x36}
C {CM_32_s.sym} 720 -1370 0 0 {name=x37}
C {MSB_UNIT_CELL.sym} 670 -1180 0 0 {name=x38}
C {MSB_UNIT_CELL.sym} 650 -570 0 0 {name=x39}
C {MSB_UNIT_CELL.sym} 670 -1000 0 0 {name=x40}
C {MSB_UNIT_CELL.sym} 670 -800 0 0 {name=x41}
C {MSB_UNIT_CELL.sym} 2980 -1550 0 0 {name=x42}
C {CM_32_s.sym} 3030 -1370 0 0 {name=x43}
C {MSB_UNIT_CELL.sym} 2970 -1200 0 0 {name=x44}
C {MSB_UNIT_CELL.sym} 2960 -570 0 0 {name=x45}
C {CM_32_s.sym} 3030 -800 0 0 {name=x47}
C {MSB_UNIT_CELL.sym} 2710 -1550 0 0 {name=x48}
C {CM_32_s.sym} 2760 -1370 0 0 {name=x49}
C {MSB_UNIT_CELL.sym} 2700 -1200 0 0 {name=x50}
C {MSB_UNIT_CELL.sym} 2690 -570 0 0 {name=x51}
C {MSB_UNIT_CELL.sym} 2710 -1000 0 0 {name=x52}
C {MSB_UNIT_CELL.sym} 2980 -1000 0 0 {name=x46}
C {CM_32_s.sym} 2760 -800 0 0 {name=x53}
C {MSB_UNIT_CELL.sym} 1190 -350 0 0 {name=x54}
C {MSB_UNIT_CELL.sym} 920 -350 0 0 {name=x55}
C {MSB_UNIT_CELL.sym} 650 -350 0 0 {name=x56}
C {CM_32_s.sym} 1500 -360 0 0 {name=x57}
C {MSB_UNIT_CELL.sym} 1770 -340 0 0 {name=x58}
C {CM_32_s.sym} 2170 -340 0 0 {name=x59}
C {MSB_UNIT_CELL.sym} 2410 -330 0 0 {name=x60}
C {MSB_UNIT_CELL.sym} 2960 -330 0 0 {name=x61}
C {MSB_UNIT_CELL.sym} 2690 -330 0 0 {name=x62}
C {MSB_UNIT_CELL.sym} 1190 -150 0 0 {name=x63}
C {MSB_UNIT_CELL.sym} 920 -150 0 0 {name=x64}
C {CM_32_s.sym} 1500 -160 0 0 {name=x65}
C {MSB_UNIT_CELL.sym} 1760 -140 0 0 {name=x66}
C {MSB_UNIT_CELL.sym} 2110 -130 0 0 {name=x67}
C {CM_32_s.sym} 2460 -130 0 0 {name=x68}
C {MSB_UNIT_CELL.sym} 2690 -130 0 0 {name=x69}
C {MSB_UNIT_CELL.sym} 1200 -1760 0 0 {name=x70}
C {MSB_UNIT_CELL.sym} 930 -1760 0 0 {name=x71}
C {CM_32_s.sym} 1530 -1760 0 0 {name=x73}
C {MSB_UNIT_CELL.sym} 1780 -1760 0 0 {name=x74}
C {CM_32_s.sym} 2180 -1760 0 0 {name=x75}
C {MSB_UNIT_CELL.sym} 2420 -1760 0 0 {name=x76}
C {MSB_UNIT_CELL.sym} 2970 -1760 0 0 {name=x77}
C {MSB_UNIT_CELL.sym} 2690 -1760 0 0 {name=x78}
C {MSB_UNIT_CELL.sym} 1200 -1960 0 0 {name=x72}
C {MSB_UNIT_CELL.sym} 930 -1960 0 0 {name=x79}
C {CM_32_s.sym} 1520 -1960 0 0 {name=x80}
C {MSB_UNIT_CELL.sym} 1780 -1960 0 0 {name=x81}
C {CM_32_s.sym} 2470 -1960 0 0 {name=x82}
C {MSB_UNIT_CELL.sym} 2120 -1960 0 0 {name=x83}
C {MSB_UNIT_CELL.sym} 2700 -1960 0 0 {name=x85}
C {devices/lab_pin.sym} 1990 -1900 0 0 {name=p1 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2020 -1700 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2030 -1490 0 0 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2040 -1310 0 0 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1410 -1120 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2330 -1140 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2590 -940 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2610 -740 0 0 {name=p8 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2590 -510 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2600 -270 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2590 -70 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2000 -2060 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2010 -1640 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1970 -1850 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2030 -1450 0 0 {name=p15 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2060 -1280 0 0 {name=p16 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1360 -1090 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2590 -1090 0 0 {name=p18 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2100 -890 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2040 -670 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1980 -440 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1980 -240 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2020 -910 0 0 {name=p23 sig_type=std_logic lab=C32_U}
C {devices/lab_pin.sym} 2090 -790 0 0 {name=p24 sig_type=std_logic lab=C32_D}
C {devices/lab_pin.sym} 2075 -1380 0 0 {name=p25 sig_type=std_logic lab=C32_U}
C {devices/lab_pin.sym} 2075 -1360 0 0 {name=p26 sig_type=std_logic lab=C32_D}
C {devices/lab_pin.sym} 1420 -1380 0 0 {name=p27 sig_type=std_logic lab=C32_U}
C {devices/lab_pin.sym} 1420 -1360 0 0 {name=p28 sig_type=std_logic lab=C32_D}
C {devices/lab_pin.sym} 840 -170 0 0 {name=p29 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1140 -170 0 0 {name=p30 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1690 -160 0 0 {name=p31 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2030 -150 0 0 {name=p32 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2630 -150 0 0 {name=p33 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2620 -350 0 0 {name=p34 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2890 -350 0 0 {name=p35 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2330 -350 0 0 {name=p36 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 550 -390 0 0 {name=p37 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1110 -390 0 0 {name=p39 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1710 -380 0 0 {name=p40 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2320 -610 0 0 {name=p42 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2600 -610 0 0 {name=p43 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2880 -610 0 0 {name=p44 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 550 -370 0 0 {name=p45 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 820 -370 0 0 {name=p46 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1100 -370 0 0 {name=p47 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1710 -360 0 0 {name=p48 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2040 -590 0 0 {name=p49 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2330 -590 0 0 {name=p50 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2600 -590 0 0 {name=p51 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2880 -590 0 0 {name=p52 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 830 -150 0 0 {name=p53 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 1130 -150 0 0 {name=p54 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1680 -140 0 0 {name=p55 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 2030 -130 0 0 {name=p56 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2620 -130 0 0 {name=p57 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2320 -330 0 0 {name=p58 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2600 -330 0 0 {name=p59 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2880 -330 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 550 -350 0 0 {name=p61 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 830 -350 0 0 {name=p62 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1100 -350 0 0 {name=p63 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1700 -340 0 0 {name=p64 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2040 -570 0 0 {name=p65 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2320 -570 0 0 {name=p66 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2600 -570 0 0 {name=p67 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2880 -570 0 0 {name=p68 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 545 -610 0 0 {name=p69 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 565 -840 0 0 {name=p70 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1120 -610 0 0 {name=p71 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1110 -840 0 0 {name=p72 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1370 -610 0 0 {name=p73 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1690 -610 0 0 {name=p74 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1705 -840 0 0 {name=p75 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2325 -840 0 0 {name=p76 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 545 -590 0 0 {name=p77 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 560 -820 0 0 {name=p78 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1125 -590 0 0 {name=p79 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1110 -820 0 0 {name=p80 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1370 -590 0 0 {name=p81 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1695 -590 0 0 {name=p82 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1705 -820 0 0 {name=p83 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2330 -820 0 0 {name=p84 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 540 -570 0 0 {name=p85 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 560 -800 0 0 {name=p86 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1120 -570 0 0 {name=p87 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1120 -800 0 0 {name=p88 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1370 -570 0 0 {name=p89 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1695 -570 0 0 {name=p90 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 1710 -800 0 0 {name=p91 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2350 -800 0 0 {name=p92 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 550 -1040 0 0 {name=p93 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 840 -1050 0 0 {name=p94 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1115 -1050 0 0 {name=p95 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1390 -1040 0 0 {name=p96 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2060 -1040 0 0 {name=p97 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2320 -1040 0 0 {name=p98 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2605 -1040 0 0 {name=p99 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2875 -1040 0 0 {name=p100 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 550 -1020 0 0 {name=p101 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 840 -1030 0 0 {name=p102 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1120 -1030 0 0 {name=p103 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1395 -1020 0 0 {name=p104 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2060 -1020 0 0 {name=p105 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2320 -1020 0 0 {name=p106 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2605 -1020 0 0 {name=p107 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2885 -1020 0 0 {name=p108 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 555 -1000 0 0 {name=p109 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 850 -1010 0 0 {name=p110 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1115 -1010 0 0 {name=p111 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1390 -1000 0 0 {name=p112 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2065 -1000 0 0 {name=p113 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2330 -1000 0 0 {name=p114 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2605 -1000 0 0 {name=p115 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2885 -1000 0 0 {name=p116 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 555 -1220 0 0 {name=p117 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 850 -1220 0 0 {name=p118 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1100 -1230 0 0 {name=p119 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1380 -1240 0 0 {name=p120 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2045 -1240 0 0 {name=p121 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2305 -1240 0 0 {name=p122 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2615 -1240 0 0 {name=p123 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2875 -1240 0 0 {name=p124 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 555 -1200 0 0 {name=p125 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 850 -1200 0 0 {name=p126 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1105 -1210 0 0 {name=p127 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1385 -1220 0 0 {name=p128 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2045 -1220 0 0 {name=p129 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2315 -1220 0 0 {name=p130 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2615 -1220 0 0 {name=p131 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2885 -1220 0 0 {name=p132 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 560 -1180 0 0 {name=p133 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 850 -1180 0 0 {name=p134 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1105 -1190 0 0 {name=p135 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1390 -1200 0 0 {name=p136 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2045 -1200 0 0 {name=p137 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2315 -1200 0 0 {name=p138 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2615 -1200 0 0 {name=p139 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2890 -1200 0 0 {name=p140 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1115 -1410 0 0 {name=p141 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1715 -1410 0 0 {name=p142 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2320 -1410 0 0 {name=p143 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2615 -1590 0 0 {name=p144 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2880 -1590 0 0 {name=p145 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2600 -1800 0 0 {name=p146 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2875 -1800 0 0 {name=p147 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2635 -2000 0 0 {name=p148 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1115 -1390 0 0 {name=p149 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1710 -1390 0 0 {name=p150 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2320 -1390 0 0 {name=p151 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2610 -1570 0 0 {name=p152 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2885 -1570 0 0 {name=p153 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2600 -1780 0 0 {name=p154 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2885 -1780 0 0 {name=p155 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2640 -1980 0 0 {name=p156 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1140 -1370 0 0 {name=p157 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 1725 -1370 0 0 {name=p158 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 2320 -1370 0 0 {name=p159 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 2605 -1550 0 0 {name=p160 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2890 -1550 0 0 {name=p161 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2600 -1760 0 0 {name=p162 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2880 -1760 0 0 {name=p163 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2635 -1960 0 0 {name=p164 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 570 -1590 0 0 {name=p165 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 860 -1590 0 0 {name=p166 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1110 -1590 0 0 {name=p167 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1395 -1590 0 0 {name=p168 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1715 -1590 0 0 {name=p169 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2065 -1590 0 0 {name=p170 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2320 -1590 0 0 {name=p171 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2335 -1800 0 0 {name=p172 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 570 -1570 0 0 {name=p173 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 855 -1570 0 0 {name=p174 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1110 -1570 0 0 {name=p175 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1400 -1570 0 0 {name=p176 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1715 -1570 0 0 {name=p177 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 2070 -1570 0 0 {name=p178 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 2325 -1570 0 0 {name=p179 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 2340 -1780 0 0 {name=p180 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 570 -1550 0 0 {name=p181 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 860 -1550 0 0 {name=p182 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1110 -1550 0 0 {name=p183 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1400 -1550 0 0 {name=p184 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1720 -1550 0 0 {name=p185 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2070 -1550 0 0 {name=p186 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2320 -1550 0 0 {name=p187 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 835 -1800 0 0 {name=p188 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1100 -1800 0 0 {name=p189 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1690 -1800 0 0 {name=p190 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 840 -2000 0 0 {name=p191 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1105 -2000 0 0 {name=p192 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1700 -2000 0 0 {name=p193 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 2040 -2000 0 0 {name=p194 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 835 -1980 0 0 {name=p195 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1110 -1980 0 0 {name=p196 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1700 -1980 0 0 {name=p197 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2040 -1980 0 0 {name=p198 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 840 -1780 0 0 {name=p199 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1120 -1780 0 0 {name=p200 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1700 -1780 0 0 {name=p201 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 835 -1960 0 0 {name=p202 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 835 -1760 0 0 {name=p203 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1110 -1760 0 0 {name=p205 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1115 -1960 0 0 {name=p206 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1690 -1760 0 0 {name=p204 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1700 -1960 0 0 {name=p207 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2035 -1960 0 0 {name=p208 sig_type=std_logic lab=C6D}
C {devices/iopin.sym} 4370 -2580 0 0 {name=p253 lab=VDD}
C {devices/iopin.sym} 4625 -2105 0 0 {name=p254 lab=VSS}
C {devices/lab_pin.sym} 1810 -1250 0 0 {name=p264 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 1680 -1200 0 0 {name=p265 sig_type=std_logic lab=B1D}
C {devices/lab_pin.sym} 1680 -1180 0 0 {name=p266 sig_type=std_logic lab=B2D}
C {devices/lab_pin.sym} 1680 -1160 0 0 {name=p267 sig_type=std_logic lab=B3D}
C {devices/lab_pin.sym} 1680 -1140 0 0 {name=p268 sig_type=std_logic lab=B4D}
C {devices/lab_pin.sym} 1680 -1120 0 0 {name=p269 sig_type=std_logic lab=B5D}
C {devices/lab_pin.sym} 1680 -1100 0 0 {name=p270 sig_type=std_logic lab=B6D}
C {devices/lab_pin.sym} 1680 -1080 0 0 {name=p271 sig_type=std_logic lab=ITAIL}
C {devices/ipin.sym} 3340 -800 0 0 {name=p273 lab=B2}
C {devices/ipin.sym} 4005 -550 0 0 {name=p274 lab=B4}
C {devices/ipin.sym} 4885 -2010 0 0 {name=p278 lab=ITAIL}
C {Thermo_Decoder.sym} 3955 -2010 0 0 {name=x84}
C {devices/lab_pin.sym} 3755 -2120 0 0 {name=p209 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3775 -1940 0 0 {name=p210 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3745 -2090 0 0 {name=p211 sig_type=std_logic lab=C6}
C {devices/lab_pin.sym} 3745 -2070 0 0 {name=p212 sig_type=std_logic lab=C5}
C {devices/lab_pin.sym} 3745 -2050 0 0 {name=p213 sig_type=std_logic lab=C4}
C {devices/lab_pin.sym} 3745 -2030 0 0 {name=p214 sig_type=std_logic lab=C3}
C {devices/lab_pin.sym} 3745 -2010 0 0 {name=p215 sig_type=std_logic lab=C2}
C {devices/lab_pin.sym} 3745 -1990 0 0 {name=p216 sig_type=std_logic lab=C1}
C {devices/lab_pin.sym} 3745 -1970 0 0 {name=p217 sig_type=std_logic lab=C0}
C {devices/lab_pin.sym} 4135 -2090 0 0 {name=p218 sig_type=std_logic lab=R6}
C {devices/lab_pin.sym} 4135 -2070 0 0 {name=p219 sig_type=std_logic lab=R5}
C {devices/lab_pin.sym} 4135 -2050 0 0 {name=p220 sig_type=std_logic lab=R4}
C {devices/lab_pin.sym} 4135 -2030 0 0 {name=p221 sig_type=std_logic lab=R3}
C {devices/lab_pin.sym} 4135 -2010 0 0 {name=p222 sig_type=std_logic lab=R2}
C {devices/lab_pin.sym} 4135 -1990 0 0 {name=p223 sig_type=std_logic lab=R1}
C {devices/lab_pin.sym} 3435 -2050 0 0 {name=p225 sig_type=std_logic lab=B9D}
C {devices/lab_pin.sym} 3435 -2030 0 0 {name=p226 sig_type=std_logic lab=B8D}
C {devices/lab_pin.sym} 3435 -2010 0 0 {name=p227 sig_type=std_logic lab=B7D}
C {devices/lab_pin.sym} 3825 -2050 0 0 {name=p228 sig_type=std_logic lab=B12D}
C {devices/lab_pin.sym} 3825 -2030 0 0 {name=p229 sig_type=std_logic lab=B11D}
C {devices/lab_pin.sym} 3825 -2010 0 0 {name=p230 sig_type=std_logic lab=B10D}
C {Thermo_Decoder.sym} 3565 -2010 0 0 {name=x86}
C {devices/lab_pin.sym} 4130 -1970 2 0 {name=p224 sig_type=std_logic lab=R0}
C {devices/lab_pin.sym} 880 -410 0 0 {name=p38 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2070 -610 1 0 {name=p41 sig_type=std_logic lab=R0D}
C {devices/opin.sym} 4500 -2385 0 0 {name=p232 lab=OUT+}
C {devices/opin.sym} 4290 -2380 0 0 {name=p231 lab=OUT-}
C {devices/lab_pin.sym} 2030 -1160 2 0 {name=p233 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2030 -1140 2 0 {name=p234 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1310 -210 0 0 {name=p235 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1330 -110 0 0 {name=p236 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1900 -190 0 0 {name=p237 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1900 -110 0 0 {name=p238 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2250 -180 0 0 {name=p239 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2250 -100 0 0 {name=p240 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2830 -180 0 0 {name=p241 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2830 -100 0 0 {name=p242 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 790 -400 0 0 {name=p243 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 790 -320 0 0 {name=p244 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1060 -400 0 0 {name=p245 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1060 -320 0 0 {name=p246 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1330 -400 0 0 {name=p247 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1330 -320 0 0 {name=p248 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1910 -390 0 0 {name=p249 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1910 -310 0 0 {name=p250 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2550 -380 0 0 {name=p251 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2550 -300 0 0 {name=p252 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2830 -380 0 0 {name=p260 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2830 -300 0 0 {name=p262 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 3100 -380 0 0 {name=p263 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 3100 -300 0 0 {name=p280 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 790 -620 0 0 {name=p281 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 790 -540 0 0 {name=p282 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1330 -620 0 0 {name=p283 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1330 -540 0 0 {name=p284 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1590 -620 0 0 {name=p285 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1590 -540 0 0 {name=p286 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1920 -620 0 0 {name=p287 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1920 -540 0 0 {name=p288 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2260 -620 0 0 {name=p289 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2260 -540 0 0 {name=p290 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2550 -620 0 0 {name=p291 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2550 -540 0 0 {name=p292 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2830 -620 0 0 {name=p293 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2830 -540 0 0 {name=p294 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 3100 -620 0 0 {name=p295 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 3100 -540 0 0 {name=p296 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 810 -850 0 0 {name=p297 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 810 -770 0 0 {name=p298 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1350 -850 0 0 {name=p299 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1350 -770 0 0 {name=p300 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1940 -850 0 0 {name=p301 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1940 -770 0 0 {name=p302 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2560 -850 0 0 {name=p303 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2560 -770 0 0 {name=p304 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 3120 -1050 0 0 {name=p305 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 3120 -970 0 0 {name=p306 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2850 -1050 0 0 {name=p307 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2850 -970 0 0 {name=p308 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2550 -1050 0 0 {name=p309 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2550 -970 0 0 {name=p310 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2290 -1050 0 0 {name=p311 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2290 -970 0 0 {name=p312 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1620 -1050 0 0 {name=p313 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1620 -970 0 0 {name=p314 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1350 -1060 0 0 {name=p315 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1350 -980 0 0 {name=p316 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1080 -1060 0 0 {name=p317 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1080 -980 0 0 {name=p318 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 810 -1050 0 0 {name=p319 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 810 -970 0 0 {name=p320 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 810 -1230 0 0 {name=p321 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 810 -1150 0 0 {name=p322 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1080 -1230 0 0 {name=p323 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1080 -1150 0 0 {name=p324 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1350 -1240 0 0 {name=p325 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1350 -1160 0 0 {name=p326 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1620 -1250 0 0 {name=p327 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1620 -1170 0 0 {name=p328 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2280 -1255 0 0 {name=p329 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2280 -1175 0 0 {name=p330 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2540 -1250 0 0 {name=p331 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2540 -1170 0 0 {name=p332 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2840 -1250 0 0 {name=p333 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2840 -1170 0 0 {name=p334 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 3110 -1250 0 0 {name=p335 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 3110 -1170 0 0 {name=p336 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1340 -1425 0 0 {name=p337 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1340 -1345 0 0 {name=p338 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1940 -1420 0 0 {name=p339 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1940 -1340 0 0 {name=p340 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2550 -1415 0 0 {name=p341 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2550 -1335 0 0 {name=p342 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 810 -1600 0 0 {name=p343 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 810 -1520 0 0 {name=p344 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1080 -1595 0 0 {name=p345 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1080 -1515 0 0 {name=p346 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1340 -1600 0 0 {name=p347 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1340 -1520 0 0 {name=p348 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1620 -1605 0 0 {name=p349 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1620 -1525 0 0 {name=p350 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1940 -1605 0 0 {name=p351 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1940 -1525 0 0 {name=p352 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2280 -1605 0 0 {name=p353 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2280 -1525 0 0 {name=p354 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2550 -1605 0 0 {name=p355 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2550 -1525 0 0 {name=p356 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2850 -1600 0 0 {name=p357 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2850 -1520 0 0 {name=p358 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 3120 -1595 0 0 {name=p359 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 3120 -1515 0 0 {name=p360 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1070 -1810 0 0 {name=p361 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1070 -1730 0 0 {name=p362 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1340 -1815 0 0 {name=p363 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1340 -1735 0 0 {name=p364 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1920 -1810 0 0 {name=p365 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1920 -1730 0 0 {name=p366 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2560 -1810 0 0 {name=p367 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2560 -1730 0 0 {name=p368 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2830 -1805 0 0 {name=p369 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2830 -1725 0 0 {name=p370 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 3110 -1810 0 0 {name=p371 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 3110 -1730 0 0 {name=p372 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1070 -2010 0 0 {name=p373 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1070 -1930 0 0 {name=p374 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1340 -2010 0 0 {name=p375 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1340 -1930 0 0 {name=p376 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1920 -2015 0 0 {name=p377 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1920 -1935 0 0 {name=p378 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2260 -2015 0 0 {name=p379 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2260 -1935 0 0 {name=p380 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2840 -2010 0 0 {name=p381 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2840 -1930 0 0 {name=p382 sig_type=std_logic lab=OUT-}
C {inv.sym} 3440 -540 0 0 {name=x87}
C {devices/ipin.sym} 3340 -550 0 0 {name=p383 lab=B1}
C {inv.sym} 3675 -540 0 0 {name=x88}
C {devices/lab_pin.sym} 3585 -640 0 0 {name=p384 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3585 -470 0 0 {name=p385 sig_type=std_logic lab=VSS}
C {inv.sym} 3440 -790 0 0 {name=x89}
C {inv.sym} 3675 -790 0 0 {name=x90}
C {devices/lab_pin.sym} 3585 -890 0 0 {name=p388 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3585 -720 0 0 {name=p389 sig_type=std_logic lab=VSS}
C {inv.sym} 4105 -540 0 0 {name=x91}
C {inv.sym} 4340 -540 0 0 {name=x92}
C {devices/lab_pin.sym} 4250 -640 0 0 {name=p387 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4250 -470 0 0 {name=p391 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4000 -805 0 0 {name=p272 lab=B3}
C {inv.sym} 4100 -795 0 0 {name=x93}
C {inv.sym} 4335 -795 0 0 {name=x94}
C {devices/lab_pin.sym} 4245 -895 0 0 {name=p393 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4245 -725 0 0 {name=p394 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4705 -805 0 0 {name=p396 lab=B5}
C {inv.sym} 4805 -795 0 0 {name=x95}
C {inv.sym} 5040 -795 0 0 {name=x96}
C {devices/lab_pin.sym} 4950 -895 0 0 {name=p397 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4950 -725 0 0 {name=p398 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4715 -555 0 0 {name=p400 lab=B6}
C {inv.sym} 4815 -545 0 0 {name=x97}
C {inv.sym} 5050 -545 0 0 {name=x98}
C {devices/lab_pin.sym} 4960 -645 0 0 {name=p401 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4960 -475 0 0 {name=p402 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 3325 -1370 0 0 {name=p275 lab=B10}
C {devices/ipin.sym} 3990 -1120 0 0 {name=p276 lab=B8}
C {inv.sym} 3425 -1110 0 0 {name=x99}
C {devices/ipin.sym} 3325 -1120 0 0 {name=p277 lab=B7}
C {inv.sym} 3660 -1110 0 0 {name=x100}
C {devices/lab_pin.sym} 3570 -1210 0 0 {name=p404 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3570 -1040 0 0 {name=p405 sig_type=std_logic lab=VSS}
C {inv.sym} 3425 -1360 0 0 {name=x101}
C {inv.sym} 3660 -1360 0 0 {name=x102}
C {devices/lab_pin.sym} 3570 -1460 0 0 {name=p407 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3570 -1290 0 0 {name=p408 sig_type=std_logic lab=VSS}
C {inv.sym} 4090 -1110 0 0 {name=x103}
C {inv.sym} 4325 -1110 0 0 {name=x104}
C {devices/lab_pin.sym} 4235 -1210 0 0 {name=p410 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4235 -1040 0 0 {name=p411 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 3985 -1375 0 0 {name=p413 lab=B11}
C {inv.sym} 4085 -1365 0 0 {name=x105}
C {inv.sym} 4320 -1365 0 0 {name=x106}
C {devices/lab_pin.sym} 4230 -1465 0 0 {name=p414 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4230 -1295 0 0 {name=p415 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4690 -1375 0 0 {name=p417 lab=B12}
C {inv.sym} 4790 -1365 0 0 {name=x107}
C {inv.sym} 5025 -1365 0 0 {name=x108}
C {devices/lab_pin.sym} 4935 -1465 0 0 {name=p418 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4935 -1295 0 0 {name=p419 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4700 -1125 0 0 {name=p421 lab=B9}
C {inv.sym} 4800 -1115 0 0 {name=x109}
C {inv.sym} 5035 -1115 0 0 {name=x110}
C {devices/lab_pin.sym} 4945 -1215 0 0 {name=p422 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4945 -1045 0 0 {name=p423 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 3540 -1740 0 0 {name=p255 lab=SEL_L}
C {inv.sym} 3640 -1730 0 0 {name=x111}
C {inv.sym} 3875 -1730 0 0 {name=x112}
C {devices/lab_pin.sym} 3785 -1830 0 0 {name=p256 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3785 -1660 0 0 {name=p257 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4070 -1740 2 0 {name=p258 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 3870 -550 2 0 {name=p259 sig_type=std_logic lab=B1D}
C {devices/lab_pin.sym} 3865 -800 2 0 {name=p261 sig_type=std_logic lab=B2D}
C {devices/lab_pin.sym} 4525 -805 2 0 {name=p279 sig_type=std_logic lab=B3D}
C {devices/lab_pin.sym} 4535 -550 2 0 {name=p386 sig_type=std_logic lab=B4D}
C {devices/lab_pin.sym} 5245 -555 2 0 {name=p390 sig_type=std_logic lab=B6D}
C {devices/lab_pin.sym} 5235 -805 2 0 {name=p392 sig_type=std_logic lab=B5D}
C {devices/lab_pin.sym} 3855 -1120 2 0 {name=p399 sig_type=std_logic lab=B7D}
C {devices/lab_pin.sym} 4525 -1120 2 0 {name=p395 sig_type=std_logic lab=B8D}
C {devices/lab_pin.sym} 5230 -1125 2 0 {name=p403 sig_type=std_logic lab=B9D}
C {devices/lab_pin.sym} 3855 -1370 2 0 {name=p409 sig_type=std_logic lab=B10D}
C {devices/lab_pin.sym} 4515 -1375 2 0 {name=p406 sig_type=std_logic lab=B11D}
C {devices/lab_pin.sym} 5215 -1375 2 0 {name=p412 sig_type=std_logic lab=B12D}
C {symbols/ppolyf_u.sym} 4290 -2460 0 0 {name=R2
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 4500 -2460 0 0 {name=R4
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 4680 -2460 0 0 {name=R6
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 4860 -2460 0 0 {name=R8
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5030 -2460 0 0 {name=R10
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5180 -2460 0 0 {name=R12
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5330 -2460 0 0 {name=R14
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5480 -2470 0 0 {name=R16
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5640 -2470 0 0 {name=R18
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5800 -2470 0 0 {name=R20
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 5960 -2470 0 0 {name=R22
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 2820 -2460 0 0 {name=R26
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3000 -2460 0 0 {name=R28
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3170 -2460 0 0 {name=R30
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3320 -2460 0 0 {name=R32
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3470 -2460 0 0 {name=R34
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3620 -2470 0 0 {name=R36
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3780 -2470 0 0 {name=R38
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 3940 -2470 0 0 {name=R40
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 4100 -2470 0 0 {name=R42
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 2690 -2460 0 0 {name=R1
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 2540 -2460 0 0 {name=R3
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 2370 -2460 0 0 {name=R5
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {symbols/ppolyf_u.sym} 2190 -2460 0 0 {name=R7
W=1.85e-06
L=10e-06
model=ppolyf_u
spiceprefix=X
m=1}
C {buffer_4x.sym} 5680 -1285 0 0 {name=x113}
C {buffer_4x.sym} 5680 -1720 0 0 {name=x114}
C {buffer_4x.sym} 5680 -1930 0 0 {name=x115}
C {buffer_4x.sym} 5675 -1480 0 0 {name=x116}
C {buffer_4x.sym} 5680 -1075 0 0 {name=x117}
C {buffer_4x.sym} 5675 -880 0 0 {name=x118}
C {buffer_4x.sym} 5670 -660 0 0 {name=x119}
C {devices/lab_pin.sym} 5840 -2030 0 0 {name=p416 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5840 -1780 0 0 {name=p420 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5845 -1545 0 0 {name=p424 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5845 -1360 0 0 {name=p425 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5845 -1155 0 0 {name=p426 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5850 -940 0 0 {name=p427 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5835 -735 0 0 {name=p428 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 5840 -1835 0 0 {name=p429 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5830 -1660 0 0 {name=p430 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5825 -1420 0 0 {name=p431 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5835 -1000 0 0 {name=p432 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5835 -805 0 0 {name=p433 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5825 -585 0 0 {name=p434 sig_type=std_logic lab=VSS}
C {buffer_4x.sym} 6695 -1300 0 0 {name=x127}
C {buffer_4x.sym} 6695 -1735 0 0 {name=x128}
C {buffer_4x.sym} 6695 -1945 0 0 {name=x129}
C {buffer_4x.sym} 6690 -1495 0 0 {name=x130}
C {buffer_4x.sym} 6695 -1090 0 0 {name=x131}
C {buffer_4x.sym} 6690 -895 0 0 {name=x132}
C {buffer_4x.sym} 6685 -675 0 0 {name=x133}
C {devices/lab_pin.sym} 6855 -2045 0 0 {name=p435 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6855 -1795 0 0 {name=p436 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6860 -1560 0 0 {name=p437 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6860 -1375 0 0 {name=p438 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6860 -1170 0 0 {name=p439 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6865 -955 0 0 {name=p440 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6850 -750 0 0 {name=p441 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 6855 -1850 0 0 {name=p442 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6845 -1675 0 0 {name=p443 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6840 -1435 0 0 {name=p444 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6850 -1015 0 0 {name=p445 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6850 -820 0 0 {name=p446 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6840 -600 0 0 {name=p447 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5565 -1930 0 0 {name=p448 sig_type=std_logic lab=R0}
C {devices/lab_pin.sym} 5565 -1720 0 0 {name=p449 sig_type=std_logic lab=R1}
C {devices/lab_pin.sym} 5550 -1480 0 0 {name=p450 sig_type=std_logic lab=R2}
C {devices/lab_pin.sym} 5560 -1285 0 0 {name=p451 sig_type=std_logic lab=R3}
C {devices/lab_pin.sym} 5555 -1075 0 0 {name=p452 sig_type=std_logic lab=R4}
C {devices/lab_pin.sym} 5545 -880 0 0 {name=p453 sig_type=std_logic lab=R5}
C {devices/lab_pin.sym} 5540 -660 0 0 {name=p454 sig_type=std_logic lab=R6}
C {devices/lab_pin.sym} 5865 -1930 0 0 {name=p455 sig_type=std_logic lab=R0m}
C {devices/lab_pin.sym} 5845 -1720 0 0 {name=p456 sig_type=std_logic lab=R1m}
C {devices/lab_pin.sym} 5860 -1480 0 0 {name=p457 sig_type=std_logic lab=R2m}
C {devices/lab_pin.sym} 5845 -1285 0 0 {name=p458 sig_type=std_logic lab=R3m}
C {devices/lab_pin.sym} 5865 -1075 0 0 {name=p459 sig_type=std_logic lab=R4m}
C {devices/lab_pin.sym} 5860 -880 0 0 {name=p460 sig_type=std_logic lab=R5m}
C {devices/lab_pin.sym} 5845 -660 0 0 {name=p461 sig_type=std_logic lab=R6m}
C {devices/lab_pin.sym} 6215 -1930 2 0 {name=p462 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 6215 -1720 2 0 {name=p463 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 6220 -1480 2 0 {name=p464 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 6220 -1290 2 0 {name=p465 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 6220 -1075 2 0 {name=p466 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 6215 -875 2 0 {name=p467 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 6210 -660 2 0 {name=p468 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 7220 -1945 2 0 {name=p469 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 7220 -1735 2 0 {name=p470 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 7225 -1495 2 0 {name=p471 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 7225 -1305 2 0 {name=p472 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 7225 -1090 2 0 {name=p473 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 7220 -890 2 0 {name=p474 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 7225 -675 2 0 {name=p475 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 6850 -1945 2 0 {name=p476 sig_type=std_logic lab=C0M}
C {devices/lab_pin.sym} 6850 -1735 2 0 {name=p477 sig_type=std_logic lab=C1M}
C {devices/lab_pin.sym} 6855 -1495 2 0 {name=p478 sig_type=std_logic lab=C2M}
C {devices/lab_pin.sym} 6870 -1300 2 0 {name=p479 sig_type=std_logic lab=C3M}
C {devices/lab_pin.sym} 6855 -1090 2 0 {name=p480 sig_type=std_logic lab=C4M}
C {devices/lab_pin.sym} 6905 -895 2 0 {name=p481 sig_type=std_logic lab=C5M}
C {devices/lab_pin.sym} 6855 -675 2 0 {name=p482 sig_type=std_logic lab=C6M}
C {devices/lab_pin.sym} 6580 -1945 0 0 {name=p483 sig_type=std_logic lab=C0}
C {devices/lab_pin.sym} 6580 -1735 0 0 {name=p484 sig_type=std_logic lab=C1}
C {devices/lab_pin.sym} 6565 -1495 0 0 {name=p485 sig_type=std_logic lab=C2}
C {devices/lab_pin.sym} 6575 -1300 0 0 {name=p486 sig_type=std_logic lab=C3}
C {devices/lab_pin.sym} 6570 -1090 0 0 {name=p487 sig_type=std_logic lab=C4}
C {devices/lab_pin.sym} 6560 -895 0 0 {name=p488 sig_type=std_logic lab=C5}
C {devices/lab_pin.sym} 6555 -675 0 0 {name=p489 sig_type=std_logic lab=C6}
C {buffer_16x.sym} 6050 -1290 0 0 {name=x141}
C {buffer_16x.sym} 6050 -1480 0 0 {name=x120}
C {buffer_16x.sym} 6050 -1075 0 0 {name=x121}
C {buffer_16x.sym} 6045 -875 0 0 {name=x122}
C {buffer_16x.sym} 6040 -660 0 0 {name=x123}
C {buffer_16x.sym} 6045 -1720 0 0 {name=x124}
C {buffer_16x.sym} 6045 -1930 0 0 {name=x125}
C {buffer_16x.sym} 7060 -1945 0 0 {name=x126}
C {buffer_16x.sym} 7060 -1735 0 0 {name=x134}
C {buffer_16x.sym} 7065 -1495 0 0 {name=x135}
C {buffer_16x.sym} 7065 -1305 0 0 {name=x136}
C {buffer_16x.sym} 7065 -1090 0 0 {name=x137}
C {buffer_16x.sym} 7060 -890 0 0 {name=x138}
C {buffer_16x.sym} 7055 -675 0 0 {name=x139}
C {devices/lab_pin.sym} 6885 -1240 0 0 {name=p490 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5860 -1225 0 0 {name=p491 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3620 -550 0 0 {name=p492 sig_type=std_logic lab=B1M}
C {devices/lab_pin.sym} 3625 -800 0 0 {name=p493 sig_type=std_logic lab=B2M}
C {devices/lab_pin.sym} 4295 -805 0 0 {name=p494 sig_type=std_logic lab=B3M}
C {devices/lab_pin.sym} 4300 -550 0 0 {name=p495 sig_type=std_logic lab=B4M}
C {devices/lab_pin.sym} 4985 -805 0 0 {name=p496 sig_type=std_logic lab=B5M}
C {devices/lab_pin.sym} 4995 -555 0 0 {name=p497 sig_type=std_logic lab=B6M}
C {devices/lab_pin.sym} 3630 -1120 0 0 {name=p498 sig_type=std_logic lab=B7M}
C {devices/lab_pin.sym} 4280 -1120 0 0 {name=p499 sig_type=std_logic lab=B8M}
C {devices/lab_pin.sym} 5005 -1125 0 0 {name=p500 sig_type=std_logic lab=B9M}
C {devices/lab_pin.sym} 3610 -1370 0 0 {name=p501 sig_type=std_logic lab=B10M}
C {devices/lab_pin.sym} 4300 -1375 0 0 {name=p502 sig_type=std_logic lab=B11M}
C {devices/lab_pin.sym} 5005 -1375 0 0 {name=p503 sig_type=std_logic lab=B12M}
