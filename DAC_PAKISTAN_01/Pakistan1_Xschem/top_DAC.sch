v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1760 -1160 2590 -1160 {
lab=VSS}
N 1760 -1330 2600 -1330 {
lab=VSS}
N 1760 -1510 2600 -1510 {
lab=VSS}
N 290 -1510 1760 -1510 {
lab=VSS}
N 550 -1720 2590 -1720 {
lab=VSS}
N 550 -1920 1380 -1920 {
lab=VSS}
N 1380 -1920 2320 -1920 {
lab=VSS}
N 1100 -1330 1760 -1330 {
lab=VSS}
N 300 -1330 1100 -1330 {
lab=VSS}
N 290 -1330 300 -1330 {
lab=VSS}
N 540 -110 540 -90 {
lab=VSS}
N 540 -90 2290 -90 {
lab=VSS}
N 2290 -90 2310 -90 {
lab=VSS}
N 810 -110 810 -90 {
lab=VSS}
N 1070 -120 1070 -90 {
lab=VSS}
N 1380 -100 1380 -90 {
lab=VSS}
N 270 -310 270 -290 {
lab=VSS}
N 270 -290 2580 -290 {
lab=VSS}
N 540 -310 540 -290 {
lab=VSS}
N 810 -310 810 -290 {
lab=VSS}
N 1070 -320 1070 -290 {
lab=VSS}
N 1390 -300 1390 -290 {
lab=VSS}
N 1740 -300 1740 -290 {
lab=VSS}
N 270 -530 2580 -530 {
lab=VSS}
N 290 -760 2600 -760 {
lab=VSS}
N 290 -960 2600 -960 {
lab=VSS}
N 560 -970 560 -960 {
lab=VSS}
N 1420 -1050 1420 -960 {
lab=VSS}
N 290 -1140 1100 -1140 {
lab=VSS}
N 1100 -1160 1100 -1140 {
lab=VSS}
N 830 -1150 830 -1140 {
lab=VSS}
N 570 -2080 570 -2050 {
lab=VDD}
N 570 -2080 2340 -2080 {
lab=VDD}
N 2340 -2080 2340 -2050 {
lab=VDD}
N 570 -1860 570 -1850 {
lab=VDD}
N 570 -1870 570 -1860 {
lab=VDD}
N 570 -1870 2610 -1870 {
lab=VDD}
N 2610 -1870 2610 -1850 {
lab=VDD}
N 840 -2080 840 -2050 {
lab=VDD}
N 1090 -2080 1090 -2040 {
lab=VDD}
N 1420 -2080 1420 -2050 {
lab=VDD}
N 1760 -2080 1760 -2050 {
lab=VDD}
N 2040 -2080 2040 -2040 {
lab=VDD}
N 2330 -1870 2330 -1850 {
lab=VDD}
N 2060 -1870 2060 -1850 {
lab=VDD}
N 1750 -1870 1750 -1840 {
lab=VDD}
N 1420 -1870 1420 -1850 {
lab=VDD}
N 1100 -1870 1100 -1840 {
lab=VDD}
N 840 -1870 840 -1850 {
lab=VDD}
N 310 -1660 310 -1640 {
lab=VDD}
N 310 -1660 2620 -1660 {
lab=VDD}
N 2620 -1660 2620 -1640 {
lab=VDD}
N 580 -1660 580 -1640 {
lab=VDD}
N 840 -1660 840 -1640 {
lab=VDD}
N 1120 -1660 1120 -1640 {
lab=VDD}
N 1440 -1660 1440 -1640 {
lab=VDD}
N 1780 -1660 1780 -1640 {
lab=VDD}
N 2050 -1660 2050 -1640 {
lab=VDD}
N 2350 -1660 2350 -1640 {
lab=VDD}
N 290 -1470 290 -1450 {
lab=VDD}
N 290 -1470 2600 -1470 {
lab=VDD}
N 2600 -1470 2600 -1450 {
lab=VDD}
N 2330 -1470 2330 -1450 {
lab=VDD}
N 2050 -1470 2050 -1460 {
lab=VDD}
N 1440 -1470 1440 -1460 {
lab=VDD}
N 1760 -1470 1760 -1450 {
lab=VDD}
N 1100 -1470 1100 -1450 {
lab=VDD}
N 840 -1470 840 -1460 {
lab=VDD}
N 560 -1470 560 -1450 {
lab=VDD}
N 310 -1280 310 -1270 {
lab=VDD}
N 310 -1290 310 -1280 {
lab=VDD}
N 310 -1300 310 -1290 {
lab=VDD}
N 310 -1300 1120 -1300 {
lab=VDD}
N 1120 -1300 1120 -1290 {
lab=VDD}
N 1120 -1300 2610 -1300 {
lab=VDD}
N 2610 -1300 2610 -1290 {
lab=VDD}
N 2340 -1300 2340 -1290 {
lab=VDD}
N 2040 -1300 2040 -1290 {
lab=VDD}
N 1780 -1300 1780 -1290 {
lab=VDD}
N 830 -970 830 -960 {
lab=VSS}
N 310 -1110 310 -1090 {
lab=VDD}
N 310 -1110 1120 -1110 {
lab=VDD}
N 1120 -1110 1120 -1090 {
lab=VDD}
N 850 -1110 850 -1100 {
lab=VDD}
N 1790 -1110 1790 -1090 {
lab=VDD}
N 1790 -1110 2620 -1110 {
lab=VDD}
N 2620 -1110 2620 -1090 {
lab=VDD}
N 2050 -1110 2050 -1090 {
lab=VDD}
N 2350 -1100 2350 -1090 {
lab=VDD}
N 2350 -1110 2350 -1100 {
lab=VDD}
N 310 -910 310 -890 {
lab=VDD}
N 310 -910 2600 -910 {
lab=VDD}
N 2600 -910 2600 -880 {
lab=VDD}
N 2330 -910 2330 -880 {
lab=VDD}
N 2060 -910 2060 -890 {
lab=VDD}
N 1770 -910 1770 -880 {
lab=VDD}
N 1440 -910 1440 -890 {
lab=VDD}
N 1100 -910 1100 -880 {
lab=VDD}
N 850 -910 850 -890 {
lab=VDD}
N 560 -910 560 -880 {
lab=VDD}
N 290 -690 290 -660 {
lab=VDD}
N 290 -690 2600 -690 {
lab=VDD}
N 2600 -690 2600 -660 {
lab=VDD}
N 2330 -690 2330 -660 {
lab=VDD}
N 2050 -690 2050 -660 {
lab=VDD}
N 1760 -690 1760 -660 {
lab=VDD}
N 1420 -690 1420 -660 {
lab=VDD}
N 1090 -690 1090 -660 {
lab=VDD}
N 830 -690 830 -660 {
lab=VDD}
N 560 -690 560 -660 {
lab=VDD}
N 290 -460 290 -440 {
lab=VDD}
N 290 -460 2600 -460 {
lab=VDD}
N 2600 -460 2600 -420 {
lab=VDD}
N 560 -260 560 -240 {
lab=VDD}
N 560 -260 2330 -260 {
lab=VDD}
N 2330 -260 2330 -220 {
lab=VDD}
N 2030 -260 2030 -210 {
lab=VDD}
N 1750 -260 1750 -220 {
lab=VDD}
N 1400 -260 1400 -230 {
lab=VDD}
N 1070 -260 1070 -240 {
lab=VDD}
N 830 -260 830 -240 {
lab=VDD}
N 580 -1300 580 -1270 {
lab=VDD}
N 850 -1300 850 -1280 {
lab=VDD}
N 1430 -1300 1430 -1250 {
lab=VDD}
N 560 -460 560 -440 {
lab=VDD}
N 830 -460 830 -440 {
lab=VDD}
N 1070 -460 1070 -440 {
lab=VDD}
N 1410 -460 1410 -430 {
lab=VDD}
N 1740 -460 1740 -420 {
lab=VDD}
N 2050 -460 2050 -420 {
lab=VDD}
N 2330 -460 2330 -420 {
lab=VDD}
N 1490 -1050 1490 -930 {
lab=C32_U}
N 1490 -930 1670 -930 {
lab=C32_U}
N 1670 -930 1670 -830 {
lab=C32_U}
N 1670 -830 1680 -830 {
lab=C32_U}
N 1470 -1050 1470 -920 {
lab=C32_D}
N 1470 -920 1650 -920 {
lab=C32_D}
N 1650 -920 1650 -810 {
lab=C32_D}
N 1650 -810 1680 -810 {
lab=C32_D}
N 1000 -930 1490 -930 {
lab=C32_U}
N 1000 -930 1000 -830 {
lab=C32_U}
N 1000 -830 1010 -830 {
lab=C32_U}
N 980 -920 1470 -920 {
lab=C32_D}
N 980 -920 980 -810 {
lab=C32_D}
N 980 -810 1010 -810 {
lab=C32_D}
N 1850 -830 1890 -830 {
lab=#net1}
N 1890 -830 1890 -805 {
lab=#net1}
N 1890 -805 1960 -805 {
lab=#net1}
N 1850 -810 1865 -810 {
lab=#net2}
N 1865 -810 1865 -790 {
lab=#net2}
N 1865 -790 1960 -790 {
lab=#net2}
N 1865 -935 1865 -830 {
lab=#net1}
N 1865 -950 1865 -935 {
lab=#net1}
N 1665 -950 1865 -950 {
lab=#net1}
N 1665 -1005 1665 -950 {
lab=#net1}
N 1665 -1005 1690 -1005 {
lab=#net1}
N 1860 -930 1860 -810 {
lab=#net2}
N 1860 -940 1860 -930 {
lab=#net2}
N 1685 -940 1860 -940 {
lab=#net2}
N 1685 -990 1685 -940 {
lab=#net2}
N 1685 -990 1690 -990 {
lab=#net2}
N 1865 -950 2225 -950 {
lab=#net1}
N 2225 -950 2225 -830 {
lab=#net1}
N 2225 -830 2240 -830 {
lab=#net1}
N 1860 -940 2205 -940 {
lab=#net2}
N 2205 -940 2205 -810 {
lab=#net2}
N 2205 -810 2240 -810 {
lab=#net2}
N 1630 -950 1665 -950 {
lab=#net1}
N 1630 -950 1630 -370 {
lab=#net1}
N 1630 -370 1650 -370 {
lab=#net1}
N 1610 -940 1685 -940 {
lab=#net2}
N 1610 -940 1610 -360 {
lab=#net2}
N 1610 -360 1610 -350 {
lab=#net2}
N 1610 -350 1650 -350 {
lab=#net2}
N 1180 -830 1230 -830 {
lab=#net3}
N 1230 -830 1230 -805 {
lab=#net3}
N 1230 -805 1340 -805 {
lab=#net3}
N 1180 -810 1200 -810 {
lab=#net4}
N 1200 -810 1200 -790 {
lab=#net4}
N 1200 -790 1335 -790 {
lab=#net4}
N 1335 -790 1340 -790 {
lab=#net4}
N 1200 -955 1200 -830 {
lab=#net3}
N 995 -955 1200 -955 {
lab=#net3}
N 995 -1005 995 -955 {
lab=#net3}
N 995 -1005 1020 -1005 {
lab=#net3}
N 1190 -940 1190 -810 {
lab=#net4}
N 980 -940 1190 -940 {
lab=#net4}
N 980 -990 980 -940 {
lab=#net4}
N 980 -990 1020 -990 {
lab=#net4}
N 960 -955 995 -955 {
lab=#net3}
N 960 -955 960 -390 {
lab=#net3}
N 960 -390 980 -390 {
lab=#net3}
N 965 -940 980 -940 {
lab=#net4}
N 965 -940 965 -370 {
lab=#net4}
N 965 -370 980 -370 {
lab=#net4}
N 465 -955 960 -955 {
lab=#net3}
N 465 -955 465 -830 {
lab=#net3}
N 465 -830 470 -830 {
lab=#net3}
N 460 -940 965 -940 {
lab=#net4}
N 460 -940 460 -810 {
lab=#net4}
N 460 -810 470 -810 {
lab=#net4}
N 1620 -1400 1670 -1400 {
lab=C32_U}
N 1620 -1380 1670 -1380 {
lab=C32_D}
N 975 -1400 1010 -1400 {
lab=C32_U}
N 975 -1380 1010 -1380 {
lab=C32_D}
N 1840 -1400 1870 -1400 {
lab=#net5}
N 1870 -1400 1870 -1320 {
lab=#net5}
N 1650 -1320 1870 -1320 {
lab=#net5}
N 1650 -1320 1650 -1205 {
lab=#net5}
N 1650 -1205 1680 -1205 {
lab=#net5}
N 1840 -1380 1855 -1380 {
lab=#net6}
N 1855 -1380 1855 -1315 {
lab=#net6}
N 1660 -1315 1855 -1315 {
lab=#net6}
N 1660 -1315 1660 -1190 {
lab=#net6}
N 1660 -1190 1680 -1190 {
lab=#net6}
N 1310 -1320 1650 -1320 {
lab=#net5}
N 1310 -1375 1310 -1320 {
lab=#net5}
N 1310 -1375 1340 -1375 {
lab=#net5}
N 1335 -1315 1660 -1315 {
lab=#net6}
N 1335 -1360 1335 -1315 {
lab=#net6}
N 1335 -1360 1340 -1360 {
lab=#net6}
N 1870 -1320 2230 -1320 {
lab=#net5}
N 2230 -1400 2230 -1320 {
lab=#net5}
N 2230 -1400 2240 -1400 {
lab=#net5}
N 1855 -1315 2240 -1315 {
lab=#net6}
N 2240 -1380 2240 -1315 {
lab=#net6}
N 1580 -1790 1580 -1320 {
lab=#net5}
N 1580 -1790 1660 -1790 {
lab=#net5}
N 1595 -1770 1595 -1315 {
lab=#net6}
N 1595 -1770 1660 -1770 {
lab=#net6}
N 1180 -1500 1180 -1400 {
lab=#net7}
N 990 -1500 1180 -1500 {
lab=#net7}
N 1180 -1380 1190 -1380 {
lab=#net8}
N 1190 -1490 1190 -1380 {
lab=#net8}
N 1005 -1490 1190 -1490 {
lab=#net8}
N 990 -1500 990 -1205 {
lab=#net7}
N 990 -1205 1020 -1205 {
lab=#net7}
N 1005 -1490 1005 -1190 {
lab=#net8}
N 1005 -1190 1020 -1190 {
lab=#net8}
N 705 -1500 990 -1500 {
lab=#net7}
N 705 -1500 705 -1375 {
lab=#net7}
N 705 -1375 740 -1375 {
lab=#net7}
N 730 -1490 1005 -1490 {
lab=#net8}
N 730 -1490 730 -1360 {
lab=#net8}
N 730 -1360 740 -1360 {
lab=#net8}
N 440 -1500 705 -1500 {
lab=#net7}
N 440 -1500 440 -1400 {
lab=#net7}
N 440 -1400 470 -1400 {
lab=#net7}
N 460 -1490 730 -1490 {
lab=#net8}
N 460 -1490 460 -1380 {
lab=#net8}
N 460 -1380 470 -1380 {
lab=#net8}
N 640 -1400 680 -1400 {
lab=#net9}
N 680 -1400 685 -1400 {
lab=#net9}
N 685 -1400 695 -1400 {
lab=#net9}
N 695 -1400 695 -1195 {
lab=#net9}
N 695 -1195 750 -1195 {
lab=#net9}
N 640 -1380 700 -1380 {
lab=#net10}
N 700 -1380 700 -1180 {
lab=#net10}
N 700 -1180 750 -1180 {
lab=#net10}
N 440 -1315 695 -1315 {
lab=#net9}
N 440 -1315 440 -1185 {
lab=#net9}
N 440 -1185 480 -1185 {
lab=#net9}
N 455 -1325 700 -1325 {
lab=#net10}
N 455 -1325 455 -1170 {
lab=#net10}
N 455 -1170 480 -1170 {
lab=#net10}
N 455 -1540 455 -1325 {
lab=#net10}
N 455 -1540 480 -1540 {
lab=#net10}
N 420 -1315 440 -1315 {
lab=#net9}
N 420 -1555 420 -1315 {
lab=#net9}
N 420 -1555 480 -1555 {
lab=#net9}
N 195 -1325 455 -1325 {
lab=#net10}
N 195 -1380 195 -1325 {
lab=#net10}
N 195 -1380 200 -1380 {
lab=#net10}
N 160 -1315 420 -1315 {
lab=#net9}
N 160 -1400 160 -1315 {
lab=#net9}
N 160 -1400 200 -1400 {
lab=#net9}
N 580 -1110 580 -1100 {
lab=VDD}
N 560 -540 560 -530 {
lab=VSS}
N 640 -830 665 -830 {
lab=#net11}
N 665 -830 665 -730 {
lab=#net11}
N 450 -730 665 -730 {
lab=#net11}
N 450 -730 450 -615 {
lab=#net11}
N 450 -615 450 -610 {
lab=#net11}
N 450 -610 470 -610 {
lab=#net11}
N 640 -810 650 -810 {
lab=#net12}
N 650 -810 650 -710 {
lab=#net12}
N 465 -710 650 -710 {
lab=#net12}
N 465 -710 465 -590 {
lab=#net12}
N 465 -590 470 -590 {
lab=#net12}
N 665 -805 750 -805 {
lab=#net11}
N 650 -790 750 -790 {
lab=#net12}
N 705 -1015 705 -805 {
lab=#net11}
N 705 -1015 750 -1015 {
lab=#net11}
N 725 -1000 725 -790 {
lab=#net12}
N 725 -1000 750 -1000 {
lab=#net12}
N 450 -945 705 -945 {
lab=#net11}
N 450 -1015 450 -945 {
lab=#net11}
N 450 -1015 480 -1015 {
lab=#net11}
N 455 -930 725 -930 {
lab=#net12}
N 455 -1000 455 -930 {
lab=#net12}
N 455 -1000 480 -1000 {
lab=#net12}
N 640 -610 665 -610 {
lab=#net13}
N 665 -610 665 -500 {
lab=#net13}
N 440 -500 665 -500 {
lab=#net13}
N 440 -500 440 -355 {
lab=#net13}
N 440 -355 460 -355 {
lab=#net13}
N 640 -590 655 -590 {
lab=#net14}
N 655 -590 655 -485 {
lab=#net14}
N 455 -485 655 -485 {
lab=#net14}
N 425 -485 455 -485 {
lab=#net14}
N 425 -485 425 -340 {
lab=#net14}
N 425 -340 460 -340 {
lab=#net14}
N 145 -500 440 -500 {
lab=#net13}
N 145 -500 145 -355 {
lab=#net13}
N 145 -355 190 -355 {
lab=#net13}
N 165 -485 425 -485 {
lab=#net14}
N 165 -485 165 -340 {
lab=#net14}
N 165 -340 190 -340 {
lab=#net14}
N 145 -800 145 -500 {
lab=#net13}
N 145 -805 145 -800 {
lab=#net13}
N 145 -805 210 -805 {
lab=#net13}
N 165 -790 165 -485 {
lab=#net14}
N 165 -790 210 -790 {
lab=#net14}
N 145 -575 190 -575 {
lab=#net13}
N 165 -560 190 -560 {
lab=#net14}
N 1150 -390 1225 -390 {
lab=#net15}
N 1225 -575 1225 -390 {
lab=#net15}
N 1225 -575 1320 -575 {
lab=#net15}
N 1150 -370 1245 -370 {
lab=#net16}
N 1245 -560 1245 -370 {
lab=#net16}
N 1245 -560 1320 -560 {
lab=#net16}
N 975 -505 1225 -505 {
lab=#net15}
N 975 -575 975 -505 {
lab=#net15}
N 975 -575 985 -575 {
lab=#net15}
N 985 -490 1245 -490 {
lab=#net16}
N 985 -560 985 -490 {
lab=#net16}
N 985 -560 990 -560 {
lab=#net16}
N 705 -505 975 -505 {
lab=#net15}
N 705 -575 705 -505 {
lab=#net15}
N 705 -575 730 -575 {
lab=#net15}
N 725 -490 985 -490 {
lab=#net16}
N 725 -560 725 -490 {
lab=#net16}
N 725 -560 730 -560 {
lab=#net16}
N 1225 -390 1225 -280 {
lab=#net15}
N 965 -190 980 -190 {
lab=#net15}
N 975 -170 980 -170 {
lab=#net16}
N 970 -170 975 -170 {
lab=#net16}
N 970 -275 970 -170 {
lab=#net16}
N 1245 -370 1245 -275 {
lab=#net16}
N 970 -275 1245 -275 {
lab=#net16}
N 955 -280 1225 -280 {
lab=#net15}
N 955 -280 955 -190 {
lab=#net15}
N 955 -190 965 -190 {
lab=#net15}
N 1820 -370 1850 -370 {
lab=#net17}
N 1850 -510 1850 -370 {
lab=#net17}
N 1620 -510 1850 -510 {
lab=#net17}
N 1620 -575 1620 -510 {
lab=#net17}
N 1620 -575 1665 -575 {
lab=#net17}
N 1820 -350 1835 -350 {
lab=#net18}
N 1835 -500 1835 -350 {
lab=#net18}
N 1660 -500 1835 -500 {
lab=#net18}
N 1660 -560 1660 -500 {
lab=#net18}
N 1835 -500 1950 -500 {
lab=#net18}
N 1950 -560 1950 -500 {
lab=#net18}
N 1850 -510 1940 -510 {
lab=#net17}
N 1940 -575 1940 -510 {
lab=#net17}
N 1940 -575 1950 -575 {
lab=#net17}
N 1270 -510 1620 -510 {
lab=#net17}
N 1270 -510 1270 -345 {
lab=#net17}
N 1270 -345 1310 -345 {
lab=#net17}
N 1255 -500 1660 -500 {
lab=#net18}
N 1255 -500 1255 -330 {
lab=#net18}
N 1255 -330 1310 -330 {
lab=#net18}
N 1895 -510 1895 -160 {
lab=#net17}
N 1895 -160 1940 -160 {
lab=#net17}
N 1920 -500 1920 -140 {
lab=#net18}
N 1920 -140 1940 -140 {
lab=#net18}
N 2410 -830 2510 -830 {
lab=#net19}
N 2410 -810 2510 -810 {
lab=#net20}
N 2450 -830 2450 -735 {
lab=#net19}
N 2175 -735 2450 -735 {
lab=#net19}
N 2175 -735 2175 -575 {
lab=#net19}
N 2175 -575 2230 -575 {
lab=#net19}
N 2435 -810 2435 -720 {
lab=#net20}
N 2195 -720 2435 -720 {
lab=#net20}
N 2195 -720 2195 -560 {
lab=#net20}
N 2195 -560 2230 -560 {
lab=#net20}
N 2175 -1005 2175 -735 {
lab=#net19}
N 2175 -1005 2250 -1005 {
lab=#net19}
N 2195 -990 2195 -720 {
lab=#net20}
N 2195 -990 2250 -990 {
lab=#net20}
N 1905 -935 2175 -935 {
lab=#net19}
N 1905 -1005 1905 -935 {
lab=#net19}
N 1905 -1005 1950 -1005 {
lab=#net19}
N 1920 -925 2195 -925 {
lab=#net20}
N 1920 -990 1920 -925 {
lab=#net20}
N 1920 -990 1950 -990 {
lab=#net20}
N 2410 -1400 2510 -1400 {
lab=#net21}
N 2410 -1380 2510 -1380 {
lab=#net22}
N 2435 -1500 2435 -1400 {
lab=#net21}
N 1915 -1500 2435 -1500 {
lab=#net21}
N 1915 -1555 1915 -1500 {
lab=#net21}
N 1915 -1555 1945 -1555 {
lab=#net21}
N 1945 -1555 1950 -1555 {
lab=#net21}
N 2425 -1490 2425 -1380 {
lab=#net22}
N 1925 -1490 2425 -1490 {
lab=#net22}
N 1925 -1540 1925 -1490 {
lab=#net22}
N 1925 -1540 1950 -1540 {
lab=#net22}
N 1915 -1500 1915 -1205 {
lab=#net21}
N 1915 -1205 1940 -1205 {
lab=#net21}
N 1925 -1490 1925 -1190 {
lab=#net22}
N 1925 -1190 1940 -1190 {
lab=#net22}
N 1915 -1375 1950 -1375 {
lab=#net21}
N 1925 -1360 1950 -1360 {
lab=#net22}
N 1830 -1790 1895 -1790 {
lab=#net23}
N 1895 -1990 1895 -1790 {
lab=#net23}
N 1895 -1990 1950 -1990 {
lab=#net23}
N 1830 -1770 1905 -1770 {
lab=#net24}
N 1905 -1970 1905 -1770 {
lab=#net24}
N 1905 -1970 1950 -1970 {
lab=#net24}
N 1850 -1790 1850 -1690 {
lab=#net23}
N 1245 -1690 1850 -1690 {
lab=#net23}
N 1245 -1690 1245 -1555 {
lab=#net23}
N 1245 -1555 1340 -1555 {
lab=#net23}
N 1870 -1770 1870 -1680 {
lab=#net24}
N 1270 -1680 1870 -1680 {
lab=#net24}
N 1270 -1680 1270 -1545 {
lab=#net24}
N 1270 -1545 1270 -1540 {
lab=#net24}
N 1270 -1540 1340 -1540 {
lab=#net24}
N 1640 -1690 1640 -1555 {
lab=#net23}
N 1640 -1555 1680 -1555 {
lab=#net23}
N 1655 -1680 1655 -1540 {
lab=#net24}
N 1655 -1540 1680 -1540 {
lab=#net24}
N 1245 -1760 1245 -1690 {
lab=#net23}
N 1245 -1765 1245 -1760 {
lab=#net23}
N 1245 -1765 1320 -1765 {
lab=#net23}
N 1270 -1750 1270 -1680 {
lab=#net24}
N 1270 -1750 1320 -1750 {
lab=#net24}
N 990 -1790 1010 -1790 {
lab=#net7}
N 1005 -1770 1010 -1770 {
lab=#net8}
N 955 -1790 955 -1500 {
lab=#net7}
N 955 -1790 990 -1790 {
lab=#net7}
N 965 -1770 965 -1490 {
lab=#net8}
N 965 -1770 1005 -1770 {
lab=#net8}
N 1180 -1790 1230 -1790 {
lab=#net25}
N 1230 -1900 1230 -1790 {
lab=#net25}
N 955 -1900 1230 -1900 {
lab=#net25}
N 955 -1990 955 -1900 {
lab=#net25}
N 955 -1990 1000 -1990 {
lab=#net25}
N 1180 -1770 1215 -1770 {
lab=#net26}
N 1215 -1890 1215 -1770 {
lab=#net26}
N 980 -1890 1215 -1890 {
lab=#net26}
N 980 -1970 980 -1890 {
lab=#net26}
N 980 -1970 1000 -1970 {
lab=#net26}
N 985 -1555 1020 -1555 {
lab=#net25}
N 985 -1900 985 -1555 {
lab=#net25}
N 995 -1890 995 -1540 {
lab=#net26}
N 995 -1540 1020 -1540 {
lab=#net26}
N 700 -1700 985 -1700 {
lab=#net25}
N 700 -1700 700 -1555 {
lab=#net25}
N 700 -1555 740 -1555 {
lab=#net25}
N 710 -1685 995 -1685 {
lab=#net26}
N 710 -1685 710 -1545 {
lab=#net26}
N 710 -1545 710 -1540 {
lab=#net26}
N 710 -1540 740 -1540 {
lab=#net26}
N 700 -1765 700 -1700 {
lab=#net25}
N 700 -1765 740 -1765 {
lab=#net25}
N 710 -1750 740 -1750 {
lab=#net26}
N 710 -1750 710 -1685 {
lab=#net26}
N 370 -1490 370 -1400 {
lab=#net27}
N 155 -1490 370 -1490 {
lab=#net27}
N 155 -1555 155 -1490 {
lab=#net27}
N 155 -1555 210 -1555 {
lab=#net27}
N 370 -1380 385 -1380 {
lab=#net28}
N 385 -1480 385 -1380 {
lab=#net28}
N 180 -1480 385 -1480 {
lab=#net28}
N 180 -1540 180 -1480 {
lab=#net28}
N 180 -1540 210 -1540 {
lab=#net28}
N 155 -1490 155 -1185 {
lab=#net27}
N 155 -1185 210 -1185 {
lab=#net27}
N 180 -1480 180 -1170 {
lab=#net28}
N 180 -1170 210 -1170 {
lab=#net28}
N 370 -1490 405 -1490 {
lab=#net27}
N 405 -1490 410 -1490 {
lab=#net27}
N 410 -1760 410 -1490 {
lab=#net27}
N 410 -1765 410 -1760 {
lab=#net27}
N 410 -1765 470 -1765 {
lab=#net27}
N 385 -1480 400 -1480 {
lab=#net28}
N 400 -1480 415 -1480 {
lab=#net28}
N 415 -1750 415 -1480 {
lab=#net28}
N 415 -1750 470 -1750 {
lab=#net28}
N 180 -1170 180 -990 {
lab=#net28}
N 180 -990 210 -990 {
lab=#net28}
N 155 -1185 155 -1005 {
lab=#net27}
N 155 -1005 210 -1005 {
lab=#net27}
N 1150 -190 1225 -190 {
lab=#net29}
N 1225 -190 1225 -145 {
lab=#net29}
N 1225 -145 1300 -145 {
lab=#net29}
N 1150 -170 1205 -170 {
lab=#net30}
N 1205 -170 1205 -130 {
lab=#net30}
N 1205 -130 1300 -130 {
lab=#net30}
N 1225 -145 1225 -80 {
lab=#net29}
N 405 -80 1225 -80 {
lab=#net29}
N 400 -155 460 -155 {
lab=#net29}
N 400 -155 400 -80 {
lab=#net29}
N 400 -80 405 -80 {
lab=#net29}
N 1205 -130 1205 -100 {
lab=#net30}
N 430 -100 1205 -100 {
lab=#net30}
N 430 -140 430 -100 {
lab=#net30}
N 430 -140 460 -140 {
lab=#net30}
N 655 -355 655 -80 {
lab=#net29}
N 655 -355 730 -355 {
lab=#net29}
N 680 -340 680 -100 {
lab=#net30}
N 680 -340 730 -340 {
lab=#net30}
N 680 -140 730 -140 {
lab=#net30}
N 655 -155 730 -155 {
lab=#net29}
N 2110 -160 2145 -160 {
lab=#net31}
N 2145 -275 2145 -160 {
lab=#net31}
N 1930 -275 2145 -275 {
lab=#net31}
N 1930 -335 1930 -275 {
lab=#net31}
N 1930 -335 1950 -335 {
lab=#net31}
N 1950 -320 1950 -270 {
lab=#net32}
N 1950 -270 2135 -270 {
lab=#net32}
N 2135 -270 2135 -140 {
lab=#net32}
N 2110 -140 2135 -140 {
lab=#net32}
N 2145 -160 2175 -160 {
lab=#net31}
N 2175 -160 2175 -135 {
lab=#net31}
N 2175 -135 2230 -135 {
lab=#net31}
N 2135 -140 2135 -120 {
lab=#net32}
N 2135 -120 2230 -120 {
lab=#net32}
N 2145 -275 2205 -275 {
lab=#net31}
N 2205 -335 2205 -275 {
lab=#net31}
N 2205 -335 2230 -335 {
lab=#net31}
N 2135 -270 2230 -270 {
lab=#net32}
N 2230 -320 2230 -270 {
lab=#net32}
N 2145 -160 2145 -70 {
lab=#net31}
N 1605 -70 2145 -70 {
lab=#net31}
N 1605 -135 1605 -70 {
lab=#net31}
N 1605 -135 1650 -135 {
lab=#net31}
N 2135 -140 2135 -80 {
lab=#net32}
N 1650 -80 2135 -80 {
lab=#net32}
N 1650 -120 1650 -80 {
lab=#net32}
N 2680 -830 2725 -830 {
lab=#net33}
N 2725 -830 2725 -730 {
lab=#net33}
N 2475 -730 2725 -730 {
lab=#net33}
N 2455 -730 2475 -730 {
lab=#net33}
N 2455 -730 2455 -575 {
lab=#net33}
N 2455 -575 2500 -575 {
lab=#net33}
N 2680 -810 2700 -810 {
lab=#net34}
N 2700 -810 2700 -715 {
lab=#net34}
N 2480 -715 2700 -715 {
lab=#net34}
N 2480 -715 2480 -560 {
lab=#net34}
N 2480 -560 2500 -560 {
lab=#net34}
N 2455 -575 2455 -335 {
lab=#net33}
N 2455 -335 2500 -335 {
lab=#net33}
N 2480 -560 2480 -320 {
lab=#net34}
N 2480 -320 2500 -320 {
lab=#net34}
N 2725 -945 2725 -830 {
lab=#net33}
N 2475 -945 2725 -945 {
lab=#net33}
N 2475 -1005 2475 -945 {
lab=#net33}
N 2475 -1005 2520 -1005 {
lab=#net33}
N 2700 -935 2700 -810 {
lab=#net34}
N 2515 -935 2700 -935 {
lab=#net34}
N 2515 -990 2515 -935 {
lab=#net34}
N 2515 -990 2520 -990 {
lab=#net34}
N 2475 -1205 2475 -1005 {
lab=#net33}
N 2475 -1205 2510 -1205 {
lab=#net33}
N 2505 -990 2515 -990 {
lab=#net34}
N 2505 -1190 2505 -990 {
lab=#net34}
N 2505 -1190 2510 -1190 {
lab=#net34}
N 2680 -1400 2700 -1400 {
lab=#net35}
N 2700 -1490 2700 -1400 {
lab=#net35}
N 2700 -1505 2700 -1490 {
lab=#net35}
N 2180 -1505 2700 -1505 {
lab=#net35}
N 2180 -1555 2180 -1505 {
lab=#net35}
N 2180 -1555 2250 -1555 {
lab=#net35}
N 2680 -1380 2690 -1380 {
lab=#net36}
N 2690 -1485 2690 -1380 {
lab=#net36}
N 2250 -1485 2690 -1485 {
lab=#net36}
N 2250 -1540 2250 -1485 {
lab=#net36}
N 2475 -1555 2475 -1505 {
lab=#net35}
N 2475 -1555 2520 -1555 {
lab=#net35}
N 2495 -1540 2495 -1485 {
lab=#net36}
N 2495 -1540 2520 -1540 {
lab=#net36}
N 2475 -1765 2475 -1555 {
lab=#net35}
N 2475 -1765 2510 -1765 {
lab=#net35}
N 2495 -1750 2495 -1540 {
lab=#net36}
N 2495 -1750 2510 -1750 {
lab=#net36}
N 2180 -1505 2180 -1205 {
lab=#net35}
N 2180 -1205 2240 -1205 {
lab=#net35}
N 2205 -1485 2250 -1485 {
lab=#net36}
N 2205 -1485 2205 -1190 {
lab=#net36}
N 2205 -1190 2240 -1190 {
lab=#net36}
N 2120 -1990 2165 -1990 {
lab=#net37}
N 2165 -1990 2175 -1990 {
lab=#net37}
N 2175 -1990 2175 -1965 {
lab=#net37}
N 2175 -1965 2240 -1965 {
lab=#net37}
N 2120 -1970 2155 -1970 {
lab=#net38}
N 2155 -1970 2155 -1950 {
lab=#net38}
N 2155 -1950 2240 -1950 {
lab=#net38}
N 2185 -1965 2185 -1765 {
lab=#net37}
N 2185 -1765 2230 -1765 {
lab=#net37}
N 2195 -1950 2195 -1750 {
lab=#net38}
N 2195 -1750 2230 -1750 {
lab=#net38}
N 1925 -1900 2185 -1900 {
lab=#net37}
N 1925 -1900 1925 -1765 {
lab=#net37}
N 1925 -1765 1960 -1765 {
lab=#net37}
N 1935 -1880 2195 -1880 {
lab=#net38}
N 1935 -1880 1935 -1750 {
lab=#net38}
N 1935 -1750 1960 -1750 {
lab=#net38}
N 2185 -2120 2185 -1970 {
lab=#net37}
N 1605 -2120 2185 -2120 {
lab=#net37}
N 1605 -2120 1605 -1965 {
lab=#net37}
N 1605 -1965 1660 -1965 {
lab=#net37}
N 2195 -2105 2195 -1950 {
lab=#net38}
N 1625 -2105 2195 -2105 {
lab=#net38}
N 1625 -2105 1625 -1950 {
lab=#net38}
N 1625 -1950 1660 -1950 {
lab=#net38}
N 1170 -1990 1240 -1990 {
lab=#net39}
N 1240 -1990 1240 -1965 {
lab=#net39}
N 1240 -1965 1320 -1965 {
lab=#net39}
N 1170 -1970 1220 -1970 {
lab=#net40}
N 1220 -1970 1220 -1950 {
lab=#net40}
N 1220 -1950 1320 -1950 {
lab=#net40}
N 1210 -2110 1210 -1990 {
lab=#net39}
N 435 -2110 1210 -2110 {
lab=#net39}
N 405 -2110 435 -2110 {
lab=#net39}
N 405 -2110 405 -1965 {
lab=#net39}
N 405 -1965 470 -1965 {
lab=#net39}
N 1190 -2095 1190 -1970 {
lab=#net40}
N 445 -2095 1190 -2095 {
lab=#net40}
N 445 -2095 445 -1950 {
lab=#net40}
N 445 -1950 470 -1950 {
lab=#net40}
N 715 -1965 740 -1965 {
lab=#net39}
N 715 -2110 715 -1965 {
lab=#net39}
N 705 -2095 705 -1950 {
lab=#net40}
N 705 -1950 740 -1950 {
lab=#net40}
N 430 -210 460 -210 {
lab=VDD}
N 430 -250 430 -210 {
lab=VDD}
N 430 -250 560 -250 {
lab=VDD}
N 730 -260 730 -210 {
lab=VDD}
N 1300 -260 1300 -200 {
lab=VDD}
N 1650 -260 1650 -190 {
lab=VDD}
N 2230 -260 2230 -190 {
lab=VDD}
N 2500 -460 2500 -390 {
lab=VDD}
N 2230 -460 2230 -390 {
lab=VDD}
N 1950 -460 1950 -390 {
lab=VDD}
N 410 -190 460 -190 {
lab=R0D}
N 700 -190 730 -190 {
lab=R0D}
N 2200 -170 2230 -170 {
lab=R0D}
N 2470 -370 2500 -370 {
lab=R0D}
N 2460 -370 2470 -370 {
lab=R0D}
N 2190 -370 2230 -370 {
lab=R0D}
N 1900 -370 1950 -370 {
lab=R0D}
N 130 -410 190 -410 {
lab=R0D}
N 670 -410 730 -410 {
lab=R0D}
N 1260 -400 1310 -400 {
lab=R0D}
N 1620 -630 1660 -630 {
lab=R0D}
N 1900 -630 1950 -630 {
lab=R0D}
N 2180 -630 2230 -630 {
lab=R0D}
N 2460 -630 2500 -630 {
lab=R0D}
N 2460 -610 2500 -610 {
lab=R1D}
N 2180 -610 2230 -610 {
lab=R1D}
N 1900 -610 1950 -610 {
lab=R1D}
N 1620 -610 1660 -610 {
lab=R1D}
N 130 -390 190 -390 {
lab=R1D}
N 400 -390 460 -390 {
lab=R1D}
N 670 -390 730 -390 {
lab=R1D}
N 1260 -380 1310 -380 {
lab=R1D}
N 410 -170 460 -170 {
lab=C0D}
N 700 -170 730 -170 {
lab=C1D}
N 1260 -160 1300 -160 {
lab=C2D}
N 1610 -150 1650 -150 {
lab=C3D}
N 2200 -150 2230 -150 {
lab=C6D}
N 1900 -350 1950 -350 {
lab=C4D}
N 2180 -350 2230 -350 {
lab=C5D}
N 2460 -350 2500 -350 {
lab=VSS}
N 130 -370 190 -370 {
lab=C0D}
N 400 -370 460 -370 {
lab=C1D}
N 680 -370 730 -370 {
lab=C2D}
N 1260 -360 1310 -360 {
lab=C3D}
N 1620 -590 1660 -590 {
lab=C4D}
N 1900 -590 1950 -590 {
lab=C5D}
N 2180 -590 2230 -590 {
lab=C6D}
N 2460 -590 2500 -590 {
lab=VSS}
N 120 -630 190 -630 {
lab=R1D}
N 120 -610 190 -610 {
lab=R2D}
N 120 -590 190 -590 {
lab=C0D}
N 690 -630 730 -630 {
lab=R1D}
N 690 -610 730 -610 {
lab=R2D}
N 690 -590 730 -590 {
lab=C2D}
N 940 -630 990 -630 {
lab=R1D}
N 940 -610 990 -610 {
lab=R2D}
N 940 -590 990 -590 {
lab=C4D}
N 985 -575 990 -575 {
lab=#net15}
N 1265 -630 1320 -630 {
lab=R1D}
N 1270 -610 1320 -610 {
lab=R2D}
N 1270 -590 1320 -590 {
lab=C5D}
N 140 -860 210 -860 {
lab=R1D}
N 140 -840 210 -840 {
lab=R2D}
N 140 -820 210 -820 {
lab=C1D}
N 685 -860 750 -860 {
lab=R1D}
N 685 -840 750 -840 {
lab=R2D}
N 685 -820 750 -820 {
lab=C3D}
N 1285 -860 1340 -860 {
lab=R1D}
N 1285 -840 1340 -840 {
lab=R2D}
N 1290 -820 1340 -820 {
lab=C6D}
N 1900 -860 1960 -860 {
lab=R1D}
N 1905 -840 1960 -840 {
lab=R2D}
N 1905 -820 1960 -820 {
lab=VSS}
N 130 -1060 210 -1060 {
lab=R2D}
N 130 -1040 210 -1040 {
lab=R3D}
N 135 -1020 210 -1020 {
lab=C0D}
N 420 -1070 480 -1070 {
lab=R2D}
N 420 -1050 480 -1050 {
lab=R3D}
N 425 -1030 480 -1030 {
lab=C1D}
N 685 -1070 750 -1070 {
lab=R2D}
N 685 -1050 750 -1050 {
lab=R3D}
N 690 -1030 750 -1030 {
lab=C2D}
N 960 -1060 1020 -1060 {
lab=R2D}
N 960 -1040 1020 -1040 {
lab=R3D}
N 965 -1020 1020 -1020 {
lab=C3D}
N 1635 -1060 1690 -1060 {
lab=R2D}
N 1635 -1040 1690 -1040 {
lab=R3D}
N 1640 -1020 1690 -1020 {
lab=C4D}
N 1895 -1060 1950 -1060 {
lab=R2D}
N 1895 -1040 1950 -1040 {
lab=R3D}
N 1895 -1020 1950 -1020 {
lab=C5D}
N 2180 -1060 2250 -1060 {
lab=R2D}
N 2180 -1040 2250 -1040 {
lab=R3D}
N 2185 -1020 2250 -1020 {
lab=C6D}
N 2450 -1060 2520 -1060 {
lab=R2D}
N 2455 -1040 2520 -1040 {
lab=R3D}
N 2455 -1020 2520 -1020 {
lab=VSS}
N 135 -1240 210 -1240 {
lab=R3D}
N 135 -1220 210 -1220 {
lab=R4D}
N 140 -1200 210 -1200 {
lab=C0D}
N 425 -1240 480 -1240 {
lab=R3D}
N 425 -1220 480 -1220 {
lab=R4D}
N 425 -1200 480 -1200 {
lab=C1D}
N 675 -1250 750 -1250 {
lab=R3D}
N 680 -1230 750 -1230 {
lab=R4D}
N 680 -1210 750 -1210 {
lab=C2D}
N 955 -1260 1020 -1260 {
lab=R3D}
N 960 -1240 1020 -1240 {
lab=R4D}
N 960 -1220 1020 -1220 {
lab=C3D}
N 1620 -1260 1680 -1260 {
lab=R3D}
N 1620 -1240 1680 -1240 {
lab=R4D}
N 1625 -1220 1680 -1220 {
lab=C4D}
N 1880 -1260 1940 -1260 {
lab=R3D}
N 1885 -1240 1940 -1240 {
lab=R4D}
N 1885 -1220 1940 -1220 {
lab=C5D}
N 2190 -1260 2240 -1260 {
lab=R3D}
N 2190 -1240 2240 -1240 {
lab=R4D}
N 2190 -1220 2240 -1220 {
lab=C6D}
N 2450 -1260 2510 -1260 {
lab=R3D}
N 2450 -1240 2510 -1240 {
lab=R4D}
N 2455 -1220 2510 -1220 {
lab=VSS}
N 690 -1430 740 -1430 {
lab=R4D}
N 690 -1410 740 -1410 {
lab=R5D}
N 700 -1390 740 -1390 {
lab=C0D}
N 1295 -1430 1340 -1430 {
lab=R4D}
N 1290 -1410 1340 -1410 {
lab=R5D}
N 1300 -1390 1340 -1390 {
lab=C1D}
N 1895 -1430 1950 -1430 {
lab=R4D}
N 1895 -1410 1950 -1410 {
lab=R5D}
N 1895 -1390 1950 -1390 {
lab=C2D}
N 2185 -1610 2250 -1610 {
lab=R4D}
N 2185 -1590 2250 -1590 {
lab=R5D}
N 2185 -1570 2250 -1570 {
lab=C3D}
N 2455 -1610 2520 -1610 {
lab=R4D}
N 2455 -1590 2520 -1590 {
lab=R5D}
N 2460 -1570 2520 -1570 {
lab=C4D}
N 2180 -1820 2230 -1820 {
lab=R4D}
N 2180 -1800 2230 -1800 {
lab=R5D}
N 2180 -1780 2230 -1780 {
lab=C6D}
N 2450 -1820 2510 -1820 {
lab=R4D}
N 2460 -1800 2510 -1800 {
lab=R5D}
N 2455 -1780 2510 -1780 {
lab=C5D}
N 2200 -2020 2240 -2020 {
lab=R4D}
N 2200 -2000 2240 -2000 {
lab=R5D}
N 2200 -1980 2240 -1980 {
lab=VSS}
N 145 -1610 210 -1610 {
lab=R5D}
N 145 -1590 210 -1590 {
lab=R6D}
N 150 -1570 210 -1570 {
lab=C0D}
N 430 -1610 480 -1610 {
lab=R5D}
N 430 -1590 480 -1590 {
lab=R6D}
N 430 -1570 480 -1570 {
lab=C1D}
N 690 -1610 740 -1610 {
lab=R5D}
N 685 -1590 740 -1590 {
lab=R6D}
N 685 -1570 740 -1570 {
lab=C2D}
N 975 -1610 1020 -1610 {
lab=R5D}
N 975 -1590 1020 -1590 {
lab=R6D}
N 975 -1570 1020 -1570 {
lab=C3D}
N 1290 -1610 1340 -1610 {
lab=R5D}
N 1290 -1590 1340 -1590 {
lab=R6D}
N 1295 -1570 1340 -1570 {
lab=C4D}
N 1645 -1610 1680 -1610 {
lab=R5D}
N 1645 -1590 1680 -1590 {
lab=R6D}
N 1650 -1570 1680 -1570 {
lab=C5D}
N 1895 -1610 1950 -1610 {
lab=R5D}
N 1900 -1590 1950 -1590 {
lab=R6D}
N 1900 -1570 1950 -1570 {
lab=C6D}
N 1910 -1820 1960 -1820 {
lab=R5D}
N 1915 -1800 1960 -1800 {
lab=R6D}
N 1915 -1780 1960 -1780 {
lab=VSS}
N 1915 -1780 1915 -1720 {
lab=VSS}
N 415 -1820 470 -1820 {
lab=R6D}
N 415 -1800 470 -1800 {
lab=VSS}
N 415 -1780 470 -1780 {
lab=C1D}
N 680 -1820 740 -1820 {
lab=R6D}
N 680 -1800 740 -1800 {
lab=VSS}
N 680 -1780 740 -1780 {
lab=C2D}
N 1260 -1820 1320 -1820 {
lab=R6D}
N 1260 -1800 1320 -1800 {
lab=VSS}
N 1260 -1780 1320 -1780 {
lab=C4D}
N 415 -2020 470 -2020 {
lab=R6D}
N 415 -2000 470 -2000 {
lab=VSS}
N 415 -1980 470 -1980 {
lab=C0D}
N 680 -2020 740 -2020 {
lab=R6D}
N 685 -2000 740 -2000 {
lab=VSS}
N 685 -1980 740 -1980 {
lab=C3D}
N 1275 -2020 1320 -2020 {
lab=R6D}
N 1275 -2000 1320 -2000 {
lab=VSS}
N 1275 -1980 1320 -1980 {
lab=C5D}
N 1615 -2020 1660 -2020 {
lab=R6D}
N 1615 -2000 1660 -2000 {
lab=VSS}
N 1615 -1980 1660 -1980 {
lab=C6D}
N 1390 -1285 1390 -1250 {
lab=SEL}
N 1255 -1220 1280 -1220 {
lab=B1D}
N 1250 -1200 1280 -1200 {
lab=B2D}
N 1255 -1180 1280 -1180 {
lab=B3D}
N 1255 -1160 1280 -1160 {
lab=B4D}
N 1255 -1140 1280 -1140 {
lab=B5D}
N 1255 -1120 1280 -1120 {
lab=B6D}
N 1260 -1100 1280 -1100 {
lab=ITAIL}
N 1580 -1180 1630 -1180 {
lab=OUT+}
N 1580 -1160 1630 -1160 {
lab=OUT-}
N 1200 -1275 1200 -1240 {
lab=OUT+}
N 1200 -1220 1200 -1185 {
lab=OUT-}
N 1200 -1070 1200 -1040 {
lab=OUT+}
N 1200 -1020 1200 -985 {
lab=OUT-}
N 930 -1270 930 -1230 {
lab=OUT+}
N 930 -1210 930 -1170 {
lab=OUT-}
N 930 -1085 930 -1050 {
lab=OUT+}
N 930 -1030 930 -1005 {
lab=OUT-}
N 660 -1095 660 -1050 {
lab=OUT+}
N 660 -1030 660 -990 {
lab=OUT-}
N 390 -1085 390 -1040 {
lab=OUT+}
N 390 -1020 390 -985 {
lab=OUT-}
N 390 -880 390 -840 {
lab=OUT+}
N 390 -820 390 -780 {
lab=OUT-}
N 930 -880 930 -840 {
lab=OUT+}
N 930 -820 930 -780 {
lab=OUT-}
N 1520 -880 1520 -840 {
lab=OUT+}
N 1520 -820 1520 -780 {
lab=OUT-}
N 2140 -880 2140 -840 {
lab=OUT+}
N 2140 -820 2140 -780 {
lab=OUT-}
N 2680 -650 2680 -610 {
lab=OUT+}
N 2680 -590 2680 -550 {
lab=OUT-}
N 2410 -650 2410 -610 {
lab=OUT+}
N 2410 -590 2410 -550 {
lab=OUT-}
N 2130 -650 2130 -610 {
lab=OUT+}
N 2130 -590 2130 -550 {
lab=OUT-}
N 1840 -650 1840 -610 {
lab=OUT+}
N 1840 -590 1840 -550 {
lab=OUT-}
N 1500 -650 1500 -610 {
lab=OUT+}
N 1500 -590 1500 -550 {
lab=OUT-}
N 1170 -650 1170 -610 {
lab=OUT+}
N 1170 -590 1170 -550 {
lab=OUT-}
N 910 -650 910 -610 {
lab=OUT+}
N 910 -590 910 -550 {
lab=OUT-}
N 370 -650 370 -610 {
lab=OUT+}
N 370 -590 370 -550 {
lab=OUT-}
N 370 -430 370 -390 {
lab=OUT+}
N 370 -370 370 -330 {
lab=OUT-}
N 640 -430 640 -390 {
lab=OUT+}
N 640 -370 640 -330 {
lab=OUT-}
N 910 -430 910 -390 {
lab=OUT+}
N 910 -370 910 -330 {
lab=OUT-}
N 1490 -420 1490 -380 {
lab=OUT+}
N 1490 -360 1490 -320 {
lab=OUT-}
N 2130 -410 2130 -370 {
lab=OUT+}
N 2130 -350 2130 -310 {
lab=OUT-}
N 2410 -410 2410 -370 {
lab=OUT+}
N 2410 -350 2410 -310 {
lab=OUT-}
N 2680 -410 2680 -370 {
lab=OUT+}
N 2680 -350 2680 -310 {
lab=OUT-}
N 640 -230 640 -190 {
lab=OUT+}
N 640 -170 640 -130 {
lab=OUT-}
N 910 -230 910 -190 {
lab=OUT+}
N 910 -170 910 -130 {
lab=OUT-}
N 1480 -220 1480 -180 {
lab=OUT+}
N 1480 -160 1480 -120 {
lab=OUT-}
N 1830 -210 1830 -170 {
lab=OUT+}
N 1830 -150 1830 -110 {
lab=OUT-}
N 2410 -210 2410 -170 {
lab=OUT+}
N 2410 -150 2410 -110 {
lab=OUT-}
N 650 -2040 650 -2000 {
lab=OUT+}
N 650 -1980 650 -1940 {
lab=OUT-}
N 920 -2040 920 -2000 {
lab=OUT+}
N 920 -1980 920 -1940 {
lab=OUT-}
N 1500 -2040 1500 -2000 {
lab=OUT+}
N 1500 -1980 1500 -1940 {
lab=OUT-}
N 1840 -2040 1840 -2000 {
lab=OUT+}
N 1840 -1980 1840 -1940 {
lab=OUT-}
N 2420 -2040 2420 -2000 {
lab=OUT+}
N 2420 -1980 2420 -1940 {
lab=OUT-}
N 2690 -1840 2690 -1800 {
lab=OUT+}
N 2690 -1780 2690 -1740 {
lab=OUT-}
N 2410 -1840 2410 -1800 {
lab=OUT+}
N 2410 -1780 2410 -1740 {
lab=OUT-}
N 2140 -1840 2140 -1800 {
lab=OUT+}
N 2140 -1780 2140 -1740 {
lab=OUT-}
N 1500 -1840 1500 -1800 {
lab=OUT+}
N 1500 -1780 1500 -1740 {
lab=OUT-}
N 920 -1840 920 -1800 {
lab=OUT+}
N 920 -1780 920 -1740 {
lab=OUT-}
N 650 -1840 650 -1800 {
lab=OUT+}
N 650 -1780 650 -1740 {
lab=OUT-}
N 390 -1630 390 -1590 {
lab=OUT+}
N 390 -1570 390 -1530 {
lab=OUT-}
N 660 -1630 660 -1590 {
lab=OUT+}
N 660 -1570 660 -1530 {
lab=OUT-}
N 920 -1630 920 -1590 {
lab=OUT+}
N 920 -1570 920 -1530 {
lab=OUT-}
N 1200 -1630 1200 -1590 {
lab=OUT+}
N 1200 -1570 1200 -1530 {
lab=OUT-}
N 1520 -1630 1520 -1590 {
lab=OUT+}
N 1520 -1570 1520 -1530 {
lab=OUT-}
N 1860 -1630 1860 -1590 {
lab=OUT+}
N 1860 -1570 1860 -1530 {
lab=OUT-}
N 2130 -1630 2130 -1590 {
lab=OUT+}
N 2130 -1570 2130 -1530 {
lab=OUT-}
N 2430 -1630 2430 -1590 {
lab=OUT+}
N 2430 -1570 2430 -1530 {
lab=OUT-}
N 2700 -1630 2700 -1590 {
lab=OUT+}
N 2700 -1570 2700 -1530 {
lab=OUT-}
N 390 -1260 390 -1220 {
lab=OUT+}
N 390 -1200 390 -1160 {
lab=OUT-}
N 660 -1260 660 -1220 {
lab=OUT+}
N 660 -1200 660 -1160 {
lab=OUT-}
N 2120 -1275 2120 -1240 {
lab=OUT+}
N 2120 -1220 2120 -1185 {
lab=OUT-}
N 2420 -1275 2420 -1240 {
lab=OUT+}
N 2420 -1220 2420 -1185 {
lab=OUT-}
N 2690 -1275 2690 -1240 {
lab=OUT+}
N 2690 -1220 2690 -1185 {
lab=OUT-}
N 920 -1445 920 -1410 {
lab=OUT+}
N 920 -1390 920 -1355 {
lab=OUT-}
N 1520 -1445 1520 -1410 {
lab=OUT+}
N 1520 -1390 1520 -1355 {
lab=OUT-}
N 2130 -1445 2130 -1410 {
lab=OUT+}
N 2130 -1390 2130 -1355 {
lab=OUT-}
N 1610 -170 1650 -170 {
lab=R0D}
N 1265 -180 1300 -180 {
lab=R0D}
N 3165 -2140 3555 -2140 {
lab=VDD}
N 3165 -1960 3555 -1960 {
lab=VSS}
N 3015 -2070 3055 -2070 {
lab=B9D}
N 3015 -2050 3055 -2050 {
lab=B8D}
N 3015 -2030 3055 -2030 {
lab=B7D}
N 3405 -2070 3445 -2070 {
lab=B12D}
N 3405 -2050 3445 -2050 {
lab=B11D}
N 3405 -2030 3445 -2030 {
lab=B10D}
N 3285 -2110 3325 -2110 {
lab=C6D}
N 3285 -2090 3325 -2090 {
lab=C5D}
N 3285 -2070 3295 -2070 {
lab=C4D}
N 3295 -2070 3325 -2070 {
lab=C4D}
N 3285 -2050 3325 -2050 {
lab=C3D}
N 3285 -2030 3325 -2030 {
lab=C2D}
N 3285 -1990 3325 -1990 {
lab=C0D}
N 3675 -2110 3715 -2110 {
lab=R6D}
N 3675 -2090 3715 -2090 {
lab=R5D}
N 3675 -2070 3685 -2070 {
lab=R4D}
N 3685 -2070 3715 -2070 {
lab=R4D}
N 3675 -2050 3715 -2050 {
lab=R3D}
N 3675 -2030 3715 -2030 {
lab=R2D}
N 3675 -2010 3715 -2010 {
lab=R1D}
N 3285 -2010 3325 -2010 {
lab=C1D}
N 3675 -1990 3715 -1990 {
lab=R0D}
N 460 -440 460 -410 {
lab=R0D}
N 1860 -1275 1860 -1240 {
lab=OUT+}
N 1860 -1220 1860 -1185 {
lab=OUT-}
N 1870 -1075 1870 -1040 {
lab=OUT+}
N 1870 -1020 1870 -985 {
lab=OUT-}
N 2130 -1075 2130 -1040 {
lab=OUT+}
N 2130 -1020 2130 -985 {
lab=OUT-}
N 2430 -1075 2430 -1040 {
lab=OUT+}
N 2430 -1020 2430 -985 {
lab=OUT-}
N 2700 -1075 2700 -1040 {
lab=OUT+}
N 2700 -1020 2700 -985 {
lab=OUT-}
N 640 -230 910 -230 {
lab=OUT+}
N 640 -130 640 -120 {
lab=OUT-}
N 640 -120 910 -120 {
lab=OUT-}
N 910 -130 910 -120 {
lab=OUT-}
N 930 -1000 930 -980 {
lab=OUT-}
N 930 -1005 930 -1000 {
lab=OUT-}
N 2185 -1970 2185 -1965 {
lab=#net37}
N 2920 -570 3010 -570 {
lab=B1}
N 3050 -660 3050 -630 {
lab=VDD}
N 3050 -660 3285 -660 {
lab=VDD}
N 3285 -660 3285 -630 {
lab=VDD}
N 3050 -510 3050 -490 {
lab=VSS}
N 3050 -490 3285 -490 {
lab=VSS}
N 3285 -510 3285 -490 {
lab=VSS}
N 3385 -570 3455 -570 {
lab=B1D}
N 2920 -820 3010 -820 {
lab=B2}
N 3050 -910 3050 -880 {
lab=VDD}
N 3050 -910 3285 -910 {
lab=VDD}
N 3285 -910 3285 -880 {
lab=VDD}
N 3050 -760 3050 -740 {
lab=VSS}
N 3050 -740 3285 -740 {
lab=VSS}
N 3285 -760 3285 -740 {
lab=VSS}
N 3385 -820 3455 -820 {
lab=B2D}
N 3585 -570 3675 -570 {
lab=B4}
N 3715 -660 3715 -630 {
lab=VDD}
N 3715 -660 3950 -660 {
lab=VDD}
N 3950 -660 3950 -630 {
lab=VDD}
N 3715 -510 3715 -490 {
lab=VSS}
N 3715 -490 3950 -490 {
lab=VSS}
N 3950 -510 3950 -490 {
lab=VSS}
N 4050 -570 4120 -570 {
lab=B4D}
N 3580 -825 3670 -825 {
lab=B3}
N 3710 -915 3710 -885 {
lab=VDD}
N 3710 -915 3945 -915 {
lab=VDD}
N 3945 -915 3945 -885 {
lab=VDD}
N 3710 -765 3710 -745 {
lab=VSS}
N 3710 -745 3945 -745 {
lab=VSS}
N 3945 -765 3945 -745 {
lab=VSS}
N 4045 -825 4115 -825 {
lab=B3D}
N 4285 -825 4375 -825 {
lab=B5}
N 4415 -915 4415 -885 {
lab=VDD}
N 4415 -915 4650 -915 {
lab=VDD}
N 4650 -915 4650 -885 {
lab=VDD}
N 4415 -765 4415 -745 {
lab=VSS}
N 4415 -745 4650 -745 {
lab=VSS}
N 4650 -765 4650 -745 {
lab=VSS}
N 4750 -825 4820 -825 {
lab=B5D}
N 4295 -575 4385 -575 {
lab=B6}
N 4425 -665 4425 -635 {
lab=VDD}
N 4425 -665 4660 -665 {
lab=VDD}
N 4660 -665 4660 -635 {
lab=VDD}
N 4425 -515 4425 -495 {
lab=VSS}
N 4425 -495 4660 -495 {
lab=VSS}
N 4660 -515 4660 -495 {
lab=VSS}
N 4760 -575 4830 -575 {
lab=B6D}
N 2905 -1140 2995 -1140 {
lab=B7}
N 3035 -1230 3035 -1200 {
lab=VDD}
N 3035 -1230 3270 -1230 {
lab=VDD}
N 3270 -1230 3270 -1200 {
lab=VDD}
N 3035 -1080 3035 -1060 {
lab=VSS}
N 3035 -1060 3270 -1060 {
lab=VSS}
N 3270 -1080 3270 -1060 {
lab=VSS}
N 3370 -1140 3440 -1140 {
lab=B7D}
N 2905 -1390 2995 -1390 {
lab=B10}
N 3035 -1480 3035 -1450 {
lab=VDD}
N 3035 -1480 3270 -1480 {
lab=VDD}
N 3270 -1480 3270 -1450 {
lab=VDD}
N 3035 -1330 3035 -1310 {
lab=VSS}
N 3035 -1310 3270 -1310 {
lab=VSS}
N 3270 -1330 3270 -1310 {
lab=VSS}
N 3370 -1390 3440 -1390 {
lab=B10D}
N 3570 -1140 3660 -1140 {
lab=B8}
N 3700 -1230 3700 -1200 {
lab=VDD}
N 3700 -1230 3935 -1230 {
lab=VDD}
N 3935 -1230 3935 -1200 {
lab=VDD}
N 3700 -1080 3700 -1060 {
lab=VSS}
N 3700 -1060 3935 -1060 {
lab=VSS}
N 3935 -1080 3935 -1060 {
lab=VSS}
N 4035 -1140 4105 -1140 {
lab=B8D}
N 3565 -1395 3655 -1395 {
lab=B11}
N 3695 -1485 3695 -1455 {
lab=VDD}
N 3695 -1485 3930 -1485 {
lab=VDD}
N 3930 -1485 3930 -1455 {
lab=VDD}
N 3695 -1335 3695 -1315 {
lab=VSS}
N 3695 -1315 3930 -1315 {
lab=VSS}
N 3930 -1335 3930 -1315 {
lab=VSS}
N 4030 -1395 4100 -1395 {
lab=B11D}
N 4270 -1395 4360 -1395 {
lab=B12}
N 4400 -1485 4400 -1455 {
lab=VDD}
N 4400 -1485 4635 -1485 {
lab=VDD}
N 4635 -1485 4635 -1455 {
lab=VDD}
N 4400 -1335 4400 -1315 {
lab=VSS}
N 4400 -1315 4635 -1315 {
lab=VSS}
N 4635 -1335 4635 -1315 {
lab=VSS}
N 4735 -1395 4805 -1395 {
lab=B12D}
N 4280 -1145 4370 -1145 {
lab=B9}
N 4410 -1235 4410 -1205 {
lab=VDD}
N 4410 -1235 4645 -1235 {
lab=VDD}
N 4645 -1235 4645 -1205 {
lab=VDD}
N 4410 -1085 4410 -1065 {
lab=VSS}
N 4410 -1065 4645 -1065 {
lab=VSS}
N 4645 -1085 4645 -1065 {
lab=VSS}
N 4745 -1145 4815 -1145 {
lab=B9D}
N 3120 -1760 3210 -1760 {
lab=SEL_L}
N 3250 -1850 3250 -1820 {
lab=VDD}
N 3250 -1850 3485 -1850 {
lab=VDD}
N 3485 -1850 3485 -1820 {
lab=VDD}
N 3250 -1700 3250 -1680 {
lab=VSS}
N 3250 -1680 3485 -1680 {
lab=VSS}
N 3485 -1700 3485 -1680 {
lab=VSS}
N 3585 -1760 3655 -1760 {
lab=SEL}
N 3150 -820 3245 -820 {
lab=B2M}
N 3150 -570 3245 -570 {
lab=B1M}
N 3810 -825 3905 -825 {
lab=B3M}
N 3815 -570 3910 -570 {
lab=B4M}
N 4515 -825 4610 -825 {
lab=B5M}
N 4525 -575 4620 -575 {
lab=B6M}
N 3135 -1390 3230 -1390 {
lab=B10M}
N 3135 -1140 3230 -1140 {
lab=B7M}
N 3800 -1140 3895 -1140 {
lab=B8M}
N 3795 -1395 3890 -1395 {
lab=B11M}
N 4500 -1395 4595 -1395 {
lab=B12M}
N 4510 -1145 4605 -1145 {
lab=B9M}
N 3350 -1760 3445 -1760 {
lab=#net41}
C {CM_LSB_s.sym} 1430 -1150 0 0 {name=x1}
C {MSB_UNIT_CELL.sym} 1380 -1390 0 0 {name=x2}
C {MSB_UNIT_CELL.sym} 1720 -1220 0 0 {name=x3}
C {MSB_UNIT_CELL.sym} 1730 -1020 0 0 {name=x4}
C {MSB_UNIT_CELL.sym} 1060 -1220 0 0 {name=x5}
C {MSB_UNIT_CELL.sym} 1060 -1020 0 0 {name=x6}
C {MSB_UNIT_CELL.sym} 1380 -820 0 0 {name=x7}
C {CM_32_s.sym} 1770 -1390 0 0 {name=x8}
C {CM_32_s.sym} 1110 -1390 0 0 {name=x9}
C {CM_32_s.sym} 1780 -820 0 0 {name=x10}
C {CM_32_s.sym} 1110 -820 0 0 {name=x11}
C {MSB_UNIT_CELL.sym} 1060 -1570 0 0 {name=x12}
C {MSB_UNIT_CELL.sym} 1380 -1570 0 0 {name=x13}
C {MSB_UNIT_CELL.sym} 1720 -1570 0 0 {name=x14}
C {MSB_UNIT_CELL.sym} 780 -1570 0 0 {name=x15}
C {MSB_UNIT_CELL.sym} 1990 -1570 0 0 {name=x16}
C {MSB_UNIT_CELL.sym} 780 -1390 0 0 {name=x17}
C {MSB_UNIT_CELL.sym} 790 -1210 0 0 {name=x18}
C {MSB_UNIT_CELL.sym} 790 -1030 0 0 {name=x19}
C {MSB_UNIT_CELL.sym} 790 -820 0 0 {name=x20}
C {MSB_UNIT_CELL.sym} 770 -590 0 0 {name=x21}
C {MSB_UNIT_CELL.sym} 1030 -590 0 0 {name=x22}
C {MSB_UNIT_CELL.sym} 1360 -590 0 0 {name=x23}
C {MSB_UNIT_CELL.sym} 1700 -590 0 0 {name=x24}
C {MSB_UNIT_CELL.sym} 1990 -590 0 0 {name=x25}
C {MSB_UNIT_CELL.sym} 2000 -820 0 0 {name=x26}
C {MSB_UNIT_CELL.sym} 1990 -1020 0 0 {name=x27}
C {MSB_UNIT_CELL.sym} 1980 -1220 0 0 {name=x28}
C {MSB_UNIT_CELL.sym} 1990 -1390 0 0 {name=x29}
C {MSB_UNIT_CELL.sym} 520 -1570 0 0 {name=x30}
C {CM_32_s.sym} 570 -1390 0 0 {name=x31}
C {MSB_UNIT_CELL.sym} 520 -1200 0 0 {name=x32}
C {MSB_UNIT_CELL.sym} 520 -1030 0 0 {name=x35}
C {CM_32_s.sym} 570 -600 0 0 {name=x33}
C {CM_32_s.sym} 570 -820 0 0 {name=x34}
C {MSB_UNIT_CELL.sym} 250 -1570 0 0 {name=x36}
C {CM_32_s.sym} 300 -1390 0 0 {name=x37}
C {MSB_UNIT_CELL.sym} 250 -1200 0 0 {name=x38}
C {MSB_UNIT_CELL.sym} 230 -590 0 0 {name=x39}
C {MSB_UNIT_CELL.sym} 250 -1020 0 0 {name=x40}
C {MSB_UNIT_CELL.sym} 250 -820 0 0 {name=x41}
C {MSB_UNIT_CELL.sym} 2560 -1570 0 0 {name=x42}
C {CM_32_s.sym} 2610 -1390 0 0 {name=x43}
C {MSB_UNIT_CELL.sym} 2550 -1220 0 0 {name=x44}
C {MSB_UNIT_CELL.sym} 2540 -590 0 0 {name=x45}
C {CM_32_s.sym} 2610 -820 0 0 {name=x47}
C {MSB_UNIT_CELL.sym} 2290 -1570 0 0 {name=x48}
C {CM_32_s.sym} 2340 -1390 0 0 {name=x49}
C {MSB_UNIT_CELL.sym} 2280 -1220 0 0 {name=x50}
C {MSB_UNIT_CELL.sym} 2270 -590 0 0 {name=x51}
C {MSB_UNIT_CELL.sym} 2290 -1020 0 0 {name=x52}
C {MSB_UNIT_CELL.sym} 2560 -1020 0 0 {name=x46}
C {CM_32_s.sym} 2340 -820 0 0 {name=x53}
C {MSB_UNIT_CELL.sym} 770 -370 0 0 {name=x54}
C {MSB_UNIT_CELL.sym} 500 -370 0 0 {name=x55}
C {MSB_UNIT_CELL.sym} 230 -370 0 0 {name=x56}
C {CM_32_s.sym} 1080 -380 0 0 {name=x57}
C {MSB_UNIT_CELL.sym} 1350 -360 0 0 {name=x58}
C {CM_32_s.sym} 1750 -360 0 0 {name=x59}
C {MSB_UNIT_CELL.sym} 1990 -350 0 0 {name=x60}
C {MSB_UNIT_CELL.sym} 2540 -350 0 0 {name=x61}
C {MSB_UNIT_CELL.sym} 2270 -350 0 0 {name=x62}
C {MSB_UNIT_CELL.sym} 770 -170 0 0 {name=x63}
C {MSB_UNIT_CELL.sym} 500 -170 0 0 {name=x64}
C {CM_32_s.sym} 1080 -180 0 0 {name=x65}
C {MSB_UNIT_CELL.sym} 1340 -160 0 0 {name=x66}
C {MSB_UNIT_CELL.sym} 1690 -150 0 0 {name=x67}
C {CM_32_s.sym} 2040 -150 0 0 {name=x68}
C {MSB_UNIT_CELL.sym} 2270 -150 0 0 {name=x69}
C {MSB_UNIT_CELL.sym} 780 -1780 0 0 {name=x70}
C {MSB_UNIT_CELL.sym} 510 -1780 0 0 {name=x71}
C {CM_32_s.sym} 1110 -1780 0 0 {name=x73}
C {MSB_UNIT_CELL.sym} 1360 -1780 0 0 {name=x74}
C {CM_32_s.sym} 1760 -1780 0 0 {name=x75}
C {MSB_UNIT_CELL.sym} 2000 -1780 0 0 {name=x76}
C {MSB_UNIT_CELL.sym} 2550 -1780 0 0 {name=x77}
C {MSB_UNIT_CELL.sym} 2270 -1780 0 0 {name=x78}
C {MSB_UNIT_CELL.sym} 780 -1980 0 0 {name=x72}
C {MSB_UNIT_CELL.sym} 510 -1980 0 0 {name=x79}
C {CM_32_s.sym} 1100 -1980 0 0 {name=x80}
C {MSB_UNIT_CELL.sym} 1360 -1980 0 0 {name=x81}
C {CM_32_s.sym} 2050 -1980 0 0 {name=x82}
C {MSB_UNIT_CELL.sym} 1700 -1980 0 0 {name=x83}
C {MSB_UNIT_CELL.sym} 2280 -1980 0 0 {name=x85}
C {devices/lab_pin.sym} 1570 -1920 0 0 {name=p1 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1600 -1720 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1610 -1510 0 0 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1620 -1330 0 0 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 990 -1140 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1910 -1160 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2170 -960 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2190 -760 0 0 {name=p8 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2170 -530 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2180 -290 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2170 -90 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1580 -2080 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1590 -1660 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1550 -1870 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1610 -1470 0 0 {name=p15 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1640 -1300 0 0 {name=p16 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 940 -1110 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2170 -1110 0 0 {name=p18 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1680 -910 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1620 -690 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1560 -460 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1560 -260 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1600 -930 0 0 {name=p23 sig_type=std_logic lab=C32_U}
C {devices/lab_pin.sym} 1670 -810 0 0 {name=p24 sig_type=std_logic lab=C32_D}
C {devices/lab_pin.sym} 1655 -1400 0 0 {name=p25 sig_type=std_logic lab=C32_U}
C {devices/lab_pin.sym} 1655 -1380 0 0 {name=p26 sig_type=std_logic lab=C32_D}
C {devices/lab_pin.sym} 1000 -1400 0 0 {name=p27 sig_type=std_logic lab=C32_U}
C {devices/lab_pin.sym} 1000 -1380 0 0 {name=p28 sig_type=std_logic lab=C32_D}
C {devices/lab_pin.sym} 420 -190 0 0 {name=p29 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 720 -190 0 0 {name=p30 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1270 -180 0 0 {name=p31 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1610 -170 0 0 {name=p32 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2210 -170 0 0 {name=p33 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2200 -370 0 0 {name=p34 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2470 -370 0 0 {name=p35 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1910 -370 0 0 {name=p36 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 130 -410 0 0 {name=p37 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 690 -410 0 0 {name=p39 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1290 -400 0 0 {name=p40 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1900 -630 0 0 {name=p42 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2180 -630 0 0 {name=p43 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 2460 -630 0 0 {name=p44 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 130 -390 0 0 {name=p45 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 400 -390 0 0 {name=p46 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 680 -390 0 0 {name=p47 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1290 -380 0 0 {name=p48 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1620 -610 0 0 {name=p49 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1910 -610 0 0 {name=p50 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2180 -610 0 0 {name=p51 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 2460 -610 0 0 {name=p52 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 410 -170 0 0 {name=p53 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 710 -170 0 0 {name=p54 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1260 -160 0 0 {name=p55 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1610 -150 0 0 {name=p56 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2200 -150 0 0 {name=p57 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 1900 -350 0 0 {name=p58 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2180 -350 0 0 {name=p59 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2460 -350 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 130 -370 0 0 {name=p61 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 410 -370 0 0 {name=p62 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 680 -370 0 0 {name=p63 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 1280 -360 0 0 {name=p64 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1620 -590 0 0 {name=p65 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1900 -590 0 0 {name=p66 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2180 -590 0 0 {name=p67 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2460 -590 0 0 {name=p68 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 125 -630 0 0 {name=p69 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 145 -860 0 0 {name=p70 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 700 -630 0 0 {name=p71 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 690 -860 0 0 {name=p72 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 950 -630 0 0 {name=p73 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1270 -630 0 0 {name=p74 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1285 -860 0 0 {name=p75 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 1905 -860 0 0 {name=p76 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 125 -610 0 0 {name=p77 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 140 -840 0 0 {name=p78 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 705 -610 0 0 {name=p79 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 690 -840 0 0 {name=p80 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 950 -610 0 0 {name=p81 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1275 -610 0 0 {name=p82 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1285 -840 0 0 {name=p83 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1910 -840 0 0 {name=p84 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 120 -590 0 0 {name=p85 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 140 -820 0 0 {name=p86 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 700 -590 0 0 {name=p87 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 700 -820 0 0 {name=p88 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 950 -590 0 0 {name=p89 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1275 -590 0 0 {name=p90 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 1290 -820 0 0 {name=p91 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 1930 -820 0 0 {name=p92 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 130 -1060 0 0 {name=p93 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 420 -1070 0 0 {name=p94 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 695 -1070 0 0 {name=p95 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 970 -1060 0 0 {name=p96 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1640 -1060 0 0 {name=p97 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 1900 -1060 0 0 {name=p98 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2185 -1060 0 0 {name=p99 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 2455 -1060 0 0 {name=p100 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 130 -1040 0 0 {name=p101 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 420 -1050 0 0 {name=p102 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 700 -1050 0 0 {name=p103 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 975 -1040 0 0 {name=p104 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1640 -1040 0 0 {name=p105 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1900 -1040 0 0 {name=p106 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2185 -1040 0 0 {name=p107 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2465 -1040 0 0 {name=p108 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 135 -1020 0 0 {name=p109 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 430 -1030 0 0 {name=p110 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 695 -1030 0 0 {name=p111 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 970 -1020 0 0 {name=p112 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1645 -1020 0 0 {name=p113 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1910 -1020 0 0 {name=p114 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2185 -1020 0 0 {name=p115 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2465 -1020 0 0 {name=p116 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 135 -1240 0 0 {name=p117 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 430 -1240 0 0 {name=p118 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 680 -1250 0 0 {name=p119 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 960 -1260 0 0 {name=p120 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1625 -1260 0 0 {name=p121 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 1885 -1260 0 0 {name=p122 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2195 -1260 0 0 {name=p123 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 2455 -1260 0 0 {name=p124 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 135 -1220 0 0 {name=p125 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 430 -1220 0 0 {name=p126 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 685 -1230 0 0 {name=p127 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 965 -1240 0 0 {name=p128 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1625 -1240 0 0 {name=p129 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1895 -1240 0 0 {name=p130 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2195 -1240 0 0 {name=p131 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2465 -1240 0 0 {name=p132 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 140 -1200 0 0 {name=p133 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 430 -1200 0 0 {name=p134 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 685 -1210 0 0 {name=p135 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 970 -1220 0 0 {name=p136 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1625 -1220 0 0 {name=p137 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1895 -1220 0 0 {name=p138 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2195 -1220 0 0 {name=p139 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2470 -1220 0 0 {name=p140 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 695 -1430 0 0 {name=p141 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1295 -1430 0 0 {name=p142 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 1900 -1430 0 0 {name=p143 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2195 -1610 0 0 {name=p144 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2460 -1610 0 0 {name=p145 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2180 -1820 0 0 {name=p146 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2455 -1820 0 0 {name=p147 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 2215 -2020 0 0 {name=p148 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 695 -1410 0 0 {name=p149 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1290 -1410 0 0 {name=p150 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1900 -1410 0 0 {name=p151 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2190 -1590 0 0 {name=p152 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2465 -1590 0 0 {name=p153 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2180 -1800 0 0 {name=p154 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2465 -1800 0 0 {name=p155 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 2220 -2000 0 0 {name=p156 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 720 -1390 0 0 {name=p157 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 1305 -1390 0 0 {name=p158 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 1900 -1390 0 0 {name=p159 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 2185 -1570 0 0 {name=p160 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 2470 -1570 0 0 {name=p161 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 2180 -1780 0 0 {name=p162 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 2460 -1780 0 0 {name=p163 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 2215 -1980 0 0 {name=p164 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 150 -1610 0 0 {name=p165 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 440 -1610 0 0 {name=p166 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 690 -1610 0 0 {name=p167 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 975 -1610 0 0 {name=p168 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1295 -1610 0 0 {name=p169 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1645 -1610 0 0 {name=p170 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1900 -1610 0 0 {name=p171 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 1915 -1820 0 0 {name=p172 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 150 -1590 0 0 {name=p173 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 435 -1590 0 0 {name=p174 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 690 -1590 0 0 {name=p175 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 980 -1590 0 0 {name=p176 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1295 -1590 0 0 {name=p177 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1650 -1590 0 0 {name=p178 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1905 -1590 0 0 {name=p179 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1920 -1800 0 0 {name=p180 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 150 -1570 0 0 {name=p181 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 440 -1570 0 0 {name=p182 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 690 -1570 0 0 {name=p183 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 980 -1570 0 0 {name=p184 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1300 -1570 0 0 {name=p185 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1650 -1570 0 0 {name=p186 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 1900 -1570 0 0 {name=p187 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 415 -1820 0 0 {name=p188 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 680 -1820 0 0 {name=p189 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1270 -1820 0 0 {name=p190 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 420 -2020 0 0 {name=p191 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 685 -2020 0 0 {name=p192 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1280 -2020 0 0 {name=p193 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 1620 -2020 0 0 {name=p194 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 415 -2000 0 0 {name=p195 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 690 -2000 0 0 {name=p196 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1280 -2000 0 0 {name=p197 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1620 -2000 0 0 {name=p198 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 420 -1800 0 0 {name=p199 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 700 -1800 0 0 {name=p200 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1280 -1800 0 0 {name=p201 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 415 -1980 0 0 {name=p202 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 415 -1780 0 0 {name=p203 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 690 -1780 0 0 {name=p205 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 695 -1980 0 0 {name=p206 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 1270 -1780 0 0 {name=p204 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 1280 -1980 0 0 {name=p207 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 1615 -1980 0 0 {name=p208 sig_type=std_logic lab=C6D}
C {devices/iopin.sym} 3940 -2320 0 0 {name=p253 lab=VDD}
C {devices/iopin.sym} 4205 -2125 0 0 {name=p254 lab=VSS}
C {devices/lab_pin.sym} 1390 -1270 0 0 {name=p264 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 1260 -1220 0 0 {name=p265 sig_type=std_logic lab=B1D}
C {devices/lab_pin.sym} 1260 -1200 0 0 {name=p266 sig_type=std_logic lab=B2D}
C {devices/lab_pin.sym} 1260 -1180 0 0 {name=p267 sig_type=std_logic lab=B3D}
C {devices/lab_pin.sym} 1260 -1160 0 0 {name=p268 sig_type=std_logic lab=B4D}
C {devices/lab_pin.sym} 1260 -1140 0 0 {name=p269 sig_type=std_logic lab=B5D}
C {devices/lab_pin.sym} 1260 -1120 0 0 {name=p270 sig_type=std_logic lab=B6D}
C {devices/lab_pin.sym} 1260 -1100 0 0 {name=p271 sig_type=std_logic lab=ITAIL}
C {devices/ipin.sym} 2920 -820 0 0 {name=p273 lab=B2}
C {devices/ipin.sym} 3585 -570 0 0 {name=p274 lab=B4}
C {devices/ipin.sym} 4465 -2030 0 0 {name=p278 lab=ITAIL}
C {Thermo_Decoder.sym} 3535 -2030 0 0 {name=x84}
C {devices/lab_pin.sym} 3335 -2140 0 0 {name=p209 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3355 -1960 0 0 {name=p210 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3325 -2110 0 0 {name=p211 sig_type=std_logic lab=C6D}
C {devices/lab_pin.sym} 3325 -2090 0 0 {name=p212 sig_type=std_logic lab=C5D}
C {devices/lab_pin.sym} 3325 -2070 0 0 {name=p213 sig_type=std_logic lab=C4D}
C {devices/lab_pin.sym} 3325 -2050 0 0 {name=p214 sig_type=std_logic lab=C3D}
C {devices/lab_pin.sym} 3325 -2030 0 0 {name=p215 sig_type=std_logic lab=C2D}
C {devices/lab_pin.sym} 3325 -2010 0 0 {name=p216 sig_type=std_logic lab=C1D}
C {devices/lab_pin.sym} 3325 -1990 0 0 {name=p217 sig_type=std_logic lab=C0D}
C {devices/lab_pin.sym} 3715 -2110 0 0 {name=p218 sig_type=std_logic lab=R6D}
C {devices/lab_pin.sym} 3715 -2090 0 0 {name=p219 sig_type=std_logic lab=R5D}
C {devices/lab_pin.sym} 3715 -2070 0 0 {name=p220 sig_type=std_logic lab=R4D}
C {devices/lab_pin.sym} 3715 -2050 0 0 {name=p221 sig_type=std_logic lab=R3D}
C {devices/lab_pin.sym} 3715 -2030 0 0 {name=p222 sig_type=std_logic lab=R2D}
C {devices/lab_pin.sym} 3715 -2010 0 0 {name=p223 sig_type=std_logic lab=R1D}
C {devices/lab_pin.sym} 3015 -2070 0 0 {name=p225 sig_type=std_logic lab=B9D}
C {devices/lab_pin.sym} 3015 -2050 0 0 {name=p226 sig_type=std_logic lab=B8D}
C {devices/lab_pin.sym} 3015 -2030 0 0 {name=p227 sig_type=std_logic lab=B7D}
C {devices/lab_pin.sym} 3405 -2070 0 0 {name=p228 sig_type=std_logic lab=B12D}
C {devices/lab_pin.sym} 3405 -2050 0 0 {name=p229 sig_type=std_logic lab=B11D}
C {devices/lab_pin.sym} 3405 -2030 0 0 {name=p230 sig_type=std_logic lab=B10D}
C {Thermo_Decoder.sym} 3145 -2030 0 0 {name=x86}
C {devices/lab_pin.sym} 3710 -1990 2 0 {name=p224 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 460 -430 0 0 {name=p38 sig_type=std_logic lab=R0D}
C {devices/lab_pin.sym} 1650 -630 1 0 {name=p41 sig_type=std_logic lab=R0D}
C {devices/opin.sym} 4370 -2235 0 0 {name=p232 lab=OUT+}
C {devices/opin.sym} 4410 -2180 0 0 {name=p231 lab=OUT-}
C {devices/lab_pin.sym} 1610 -1180 2 0 {name=p233 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1610 -1160 2 0 {name=p234 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 890 -230 0 0 {name=p235 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 910 -130 0 0 {name=p236 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1480 -210 0 0 {name=p237 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1480 -130 0 0 {name=p238 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1830 -200 0 0 {name=p239 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1830 -120 0 0 {name=p240 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2410 -200 0 0 {name=p241 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2410 -120 0 0 {name=p242 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 370 -420 0 0 {name=p243 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 370 -340 0 0 {name=p244 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 640 -420 0 0 {name=p245 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 640 -340 0 0 {name=p246 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 910 -420 0 0 {name=p247 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 910 -340 0 0 {name=p248 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1490 -410 0 0 {name=p249 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1490 -330 0 0 {name=p250 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2130 -400 0 0 {name=p251 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2130 -320 0 0 {name=p252 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2410 -400 0 0 {name=p260 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2410 -320 0 0 {name=p262 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2680 -400 0 0 {name=p263 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2680 -320 0 0 {name=p280 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 370 -640 0 0 {name=p281 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 370 -560 0 0 {name=p282 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 910 -640 0 0 {name=p283 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 910 -560 0 0 {name=p284 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1170 -640 0 0 {name=p285 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1170 -560 0 0 {name=p286 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1500 -640 0 0 {name=p287 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1500 -560 0 0 {name=p288 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1840 -640 0 0 {name=p289 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1840 -560 0 0 {name=p290 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2130 -640 0 0 {name=p291 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2130 -560 0 0 {name=p292 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2410 -640 0 0 {name=p293 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2410 -560 0 0 {name=p294 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2680 -640 0 0 {name=p295 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2680 -560 0 0 {name=p296 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 390 -870 0 0 {name=p297 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 390 -790 0 0 {name=p298 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 930 -870 0 0 {name=p299 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 930 -790 0 0 {name=p300 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1520 -870 0 0 {name=p301 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1520 -790 0 0 {name=p302 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2140 -870 0 0 {name=p303 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2140 -790 0 0 {name=p304 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2700 -1070 0 0 {name=p305 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2700 -990 0 0 {name=p306 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2430 -1070 0 0 {name=p307 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2430 -990 0 0 {name=p308 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2130 -1070 0 0 {name=p309 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2130 -990 0 0 {name=p310 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1870 -1070 0 0 {name=p311 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1870 -990 0 0 {name=p312 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1200 -1070 0 0 {name=p313 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1200 -990 0 0 {name=p314 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 930 -1080 0 0 {name=p315 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 930 -1000 0 0 {name=p316 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 660 -1080 0 0 {name=p317 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 660 -1000 0 0 {name=p318 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 390 -1070 0 0 {name=p319 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 390 -990 0 0 {name=p320 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 390 -1250 0 0 {name=p321 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 390 -1170 0 0 {name=p322 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 660 -1250 0 0 {name=p323 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 660 -1170 0 0 {name=p324 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 930 -1260 0 0 {name=p325 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 930 -1180 0 0 {name=p326 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1200 -1270 0 0 {name=p327 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1200 -1190 0 0 {name=p328 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1860 -1275 0 0 {name=p329 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1860 -1195 0 0 {name=p330 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2120 -1270 0 0 {name=p331 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2120 -1190 0 0 {name=p332 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2420 -1270 0 0 {name=p333 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2420 -1190 0 0 {name=p334 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2690 -1270 0 0 {name=p335 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2690 -1190 0 0 {name=p336 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 920 -1445 0 0 {name=p337 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 920 -1365 0 0 {name=p338 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1520 -1440 0 0 {name=p339 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1520 -1360 0 0 {name=p340 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2130 -1435 0 0 {name=p341 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2130 -1355 0 0 {name=p342 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 390 -1620 0 0 {name=p343 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 390 -1540 0 0 {name=p344 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 660 -1615 0 0 {name=p345 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 660 -1535 0 0 {name=p346 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 920 -1620 0 0 {name=p347 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 920 -1540 0 0 {name=p348 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1200 -1625 0 0 {name=p349 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1200 -1545 0 0 {name=p350 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1520 -1625 0 0 {name=p351 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1520 -1545 0 0 {name=p352 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1860 -1625 0 0 {name=p353 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1860 -1545 0 0 {name=p354 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2130 -1625 0 0 {name=p355 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2130 -1545 0 0 {name=p356 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2430 -1620 0 0 {name=p357 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2430 -1540 0 0 {name=p358 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2700 -1615 0 0 {name=p359 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2700 -1535 0 0 {name=p360 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 650 -1830 0 0 {name=p361 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 650 -1750 0 0 {name=p362 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 920 -1835 0 0 {name=p363 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 920 -1755 0 0 {name=p364 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1500 -1830 0 0 {name=p365 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1500 -1750 0 0 {name=p366 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2140 -1830 0 0 {name=p367 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2140 -1750 0 0 {name=p368 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2410 -1825 0 0 {name=p369 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2410 -1745 0 0 {name=p370 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2690 -1830 0 0 {name=p371 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2690 -1750 0 0 {name=p372 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 650 -2030 0 0 {name=p373 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 650 -1950 0 0 {name=p374 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 920 -2030 0 0 {name=p375 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 920 -1950 0 0 {name=p376 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1500 -2035 0 0 {name=p377 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1500 -1955 0 0 {name=p378 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 1840 -2035 0 0 {name=p379 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 1840 -1955 0 0 {name=p380 sig_type=std_logic lab=OUT-}
C {devices/lab_pin.sym} 2420 -2030 0 0 {name=p381 sig_type=std_logic lab=OUT+}
C {devices/lab_pin.sym} 2420 -1950 0 0 {name=p382 sig_type=std_logic lab=OUT-}
C {inv.sym} 3020 -560 0 0 {name=x87}
C {devices/ipin.sym} 2920 -570 0 0 {name=p383 lab=B1}
C {inv.sym} 3255 -560 0 0 {name=x88}
C {devices/lab_pin.sym} 3165 -660 0 0 {name=p384 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3165 -490 0 0 {name=p385 sig_type=std_logic lab=VSS}
C {inv.sym} 3020 -810 0 0 {name=x89}
C {inv.sym} 3255 -810 0 0 {name=x90}
C {devices/lab_pin.sym} 3165 -910 0 0 {name=p388 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3165 -740 0 0 {name=p389 sig_type=std_logic lab=VSS}
C {inv.sym} 3685 -560 0 0 {name=x91}
C {inv.sym} 3920 -560 0 0 {name=x92}
C {devices/lab_pin.sym} 3830 -660 0 0 {name=p387 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3830 -490 0 0 {name=p391 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 3580 -825 0 0 {name=p272 lab=B3}
C {inv.sym} 3680 -815 0 0 {name=x93}
C {inv.sym} 3915 -815 0 0 {name=x94}
C {devices/lab_pin.sym} 3825 -915 0 0 {name=p393 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3825 -745 0 0 {name=p394 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4285 -825 0 0 {name=p396 lab=B5}
C {inv.sym} 4385 -815 0 0 {name=x95}
C {inv.sym} 4620 -815 0 0 {name=x96}
C {devices/lab_pin.sym} 4530 -915 0 0 {name=p397 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4530 -745 0 0 {name=p398 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4295 -575 0 0 {name=p400 lab=B6}
C {inv.sym} 4395 -565 0 0 {name=x97}
C {inv.sym} 4630 -565 0 0 {name=x98}
C {devices/lab_pin.sym} 4540 -665 0 0 {name=p401 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4540 -495 0 0 {name=p402 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 2905 -1390 0 0 {name=p275 lab=B10}
C {devices/ipin.sym} 3570 -1140 0 0 {name=p276 lab=B8}
C {inv.sym} 3005 -1130 0 0 {name=x99}
C {devices/ipin.sym} 2905 -1140 0 0 {name=p277 lab=B7}
C {inv.sym} 3240 -1130 0 0 {name=x100}
C {devices/lab_pin.sym} 3150 -1230 0 0 {name=p404 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -1060 0 0 {name=p405 sig_type=std_logic lab=VSS}
C {inv.sym} 3005 -1380 0 0 {name=x101}
C {inv.sym} 3240 -1380 0 0 {name=x102}
C {devices/lab_pin.sym} 3150 -1480 0 0 {name=p407 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3150 -1310 0 0 {name=p408 sig_type=std_logic lab=VSS}
C {inv.sym} 3670 -1130 0 0 {name=x103}
C {inv.sym} 3905 -1130 0 0 {name=x104}
C {devices/lab_pin.sym} 3815 -1230 0 0 {name=p410 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3815 -1060 0 0 {name=p411 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 3565 -1395 0 0 {name=p413 lab=B11}
C {inv.sym} 3665 -1385 0 0 {name=x105}
C {inv.sym} 3900 -1385 0 0 {name=x106}
C {devices/lab_pin.sym} 3810 -1485 0 0 {name=p414 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3810 -1315 0 0 {name=p415 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4270 -1395 0 0 {name=p417 lab=B12}
C {inv.sym} 4370 -1385 0 0 {name=x107}
C {inv.sym} 4605 -1385 0 0 {name=x108}
C {devices/lab_pin.sym} 4515 -1485 0 0 {name=p418 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4515 -1315 0 0 {name=p419 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 4280 -1145 0 0 {name=p421 lab=B9}
C {inv.sym} 4380 -1135 0 0 {name=x109}
C {inv.sym} 4615 -1135 0 0 {name=x110}
C {devices/lab_pin.sym} 4525 -1235 0 0 {name=p422 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4525 -1065 0 0 {name=p423 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 3120 -1760 0 0 {name=p255 lab=SEL_L}
C {inv.sym} 3220 -1750 0 0 {name=x111}
C {inv.sym} 3455 -1750 0 0 {name=x112}
C {devices/lab_pin.sym} 3365 -1850 0 0 {name=p256 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3365 -1680 0 0 {name=p257 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3650 -1760 2 0 {name=p258 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 3450 -570 2 0 {name=p259 sig_type=std_logic lab=B1D}
C {devices/lab_pin.sym} 3445 -820 2 0 {name=p261 sig_type=std_logic lab=B2D}
C {devices/lab_pin.sym} 4105 -825 2 0 {name=p279 sig_type=std_logic lab=B3D}
C {devices/lab_pin.sym} 4115 -570 2 0 {name=p386 sig_type=std_logic lab=B4D}
C {devices/lab_pin.sym} 4825 -575 2 0 {name=p390 sig_type=std_logic lab=B6D}
C {devices/lab_pin.sym} 4815 -825 2 0 {name=p392 sig_type=std_logic lab=B5D}
C {devices/lab_pin.sym} 3435 -1140 2 0 {name=p399 sig_type=std_logic lab=B7D}
C {devices/lab_pin.sym} 4105 -1140 2 0 {name=p395 sig_type=std_logic lab=B8D}
C {devices/lab_pin.sym} 4810 -1145 2 0 {name=p403 sig_type=std_logic lab=B9D}
C {devices/lab_pin.sym} 3435 -1390 2 0 {name=p409 sig_type=std_logic lab=B10D}
C {devices/lab_pin.sym} 4095 -1395 2 0 {name=p406 sig_type=std_logic lab=B11D}
C {devices/lab_pin.sym} 4795 -1395 2 0 {name=p412 sig_type=std_logic lab=B12D}
C {devices/lab_pin.sym} 3200 -570 0 0 {name=p492 sig_type=std_logic lab=B1M}
C {devices/lab_pin.sym} 3205 -820 0 0 {name=p493 sig_type=std_logic lab=B2M}
C {devices/lab_pin.sym} 3875 -825 0 0 {name=p494 sig_type=std_logic lab=B3M}
C {devices/lab_pin.sym} 3880 -570 0 0 {name=p495 sig_type=std_logic lab=B4M}
C {devices/lab_pin.sym} 4565 -825 0 0 {name=p496 sig_type=std_logic lab=B5M}
C {devices/lab_pin.sym} 4575 -575 0 0 {name=p497 sig_type=std_logic lab=B6M}
C {devices/lab_pin.sym} 3210 -1140 0 0 {name=p498 sig_type=std_logic lab=B7M}
C {devices/lab_pin.sym} 3860 -1140 0 0 {name=p499 sig_type=std_logic lab=B8M}
C {devices/lab_pin.sym} 4585 -1145 0 0 {name=p500 sig_type=std_logic lab=B9M}
C {devices/lab_pin.sym} 3190 -1390 0 0 {name=p501 sig_type=std_logic lab=B10M}
C {devices/lab_pin.sym} 3880 -1395 0 0 {name=p502 sig_type=std_logic lab=B11M}
C {devices/lab_pin.sym} 4585 -1395 0 0 {name=p503 sig_type=std_logic lab=B12M}
