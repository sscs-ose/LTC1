v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -120 -20 140 -20 {}
L 4 -120 20 140 20 {}
L 4 -120 -20 -120 20 {}
L 4 140 -20 140 20 {}
L 4 -140 0 -120 0 {}
L 7 140 -10 160 -10 {}
L 7 140 10 160 10 {}
B 5 157.5 -12.5 162.5 -7.5 {name=OUT dir=inout}
B 5 -142.5 -2.5 -137.5 2.5 {name=IM dir=in}
B 5 157.5 7.5 162.5 12.5 {name=VSS dir=inout}
T {CM_LSB} -35 -6 0 0 0.3 0.3 {}
T {OUT} 135 -14 0 1 0.2 0.2 {}
T {IM} -115 -4 0 0 0.2 0.2 {}
T {VSS} 135 6 0 1 0.2 0.2 {}
