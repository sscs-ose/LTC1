v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {PLL_TOP1.sym} 110 -10 0 0 {name=x1}
