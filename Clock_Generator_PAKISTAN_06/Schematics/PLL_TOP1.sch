v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 850 -610 850 -540 {
lab=VDD}
N 780 -610 850 -610 {
lab=VDD}
N 850 -420 850 -380 {
lab=VSS}
N 630 -490 700 -490 {
lab=VCTRL_OBV}
N 590 -470 700 -470 {
lab=VCTRL2}
N 70 -640 70 -610 {
lab=VDD}
N 70 -480 70 -450 {
lab=VSS}
N 110 -670 110 -610 {
lab=ITAIL1}
N 90 -670 90 -610 {
lab=ITAIL}
N -560 -690 -560 -660 {
lab=VDD}
N -560 -530 -560 -500 {
lab=VSS}
N -440 -610 -430 -610 {
lab=#net1}
N 110 -70 110 -30 {
lab=VDD}
N 1000 -500 1150 -500 {
lab=#net2}
N 1000 -470 1150 -470 {
lab=#net3}
N -360 -910 -320 -910 {
lab=#net1}
N -350 -890 -320 -890 {
lab=UP_INPUT}
N -360 -890 -350 -890 {
lab=UP_INPUT}
N -360 -870 -320 -870 {
lab=S2}
N -170 -980 -170 -940 {
lab=VDD}
N -170 -840 -170 -810 {
lab=VSS}
N -200 -440 -200 -410 {
lab=VDD}
N -360 -380 -340 -380 {
lab=#net4}
N -350 -360 -340 -360 {
lab=DN_INPUT}
N -360 -340 -340 -340 {
lab=S3}
N -50 -360 -20 -360 {
lab=DN}
N -200 -310 -200 -290 {
lab=VSS}
N 160 -20 160 -10 {
lab=#net5}
N 160 80 160 110 {
lab=VSS}
N -440 -580 -420 -580 {
lab=#net4}
N -1060 -770 -1020 -770 {
lab=OUT1_PRE}
N -1050 -750 -1020 -750 {
lab=F_IN}
N -1060 -750 -1050 -750 {
lab=F_IN}
N -1060 -730 -1020 -730 {
lab=S1}
N -870 -840 -870 -800 {
lab=VDD}
N -870 -700 -870 -670 {
lab=VSS}
N -1090 -440 -1050 -440 {
lab=DIV_OUT}
N -1080 -420 -1050 -420 {
lab=DIV_OUT2}
N -1090 -420 -1080 -420 {
lab=DIV_OUT2}
N -1090 -400 -1050 -400 {
lab=S6}
N -900 -510 -900 -470 {
lab=VDD}
N -900 -370 -900 -340 {
lab=VSS}
N 60 0 60 20 {
lab=VSS}
N 60 -120 60 -90 {
lab=#net6}
N 60 -120 160 -120 {
lab=#net6}
N 290 -680 360 -680 {
lab=#net7}
N 630 -580 630 -490 {
lab=VCTRL_OBV}
N 630 -580 700 -580 {
lab=VCTRL_OBV}
N 700 -660 700 -580 {
lab=VCTRL_OBV}
N 360 -680 370 -680 {
lab=#net7}
N 670 -660 700 -660 {
lab=VCTRL_OBV}
N 520 -720 520 -710 {
lab=VDD}
N 520 -610 520 -590 {
lab=VSS}
N 350 -660 370 -660 {
lab=VCTRL_IN}
N 340 -640 370 -640 {
lab=S4}
N -100 -560 -80 -560 {
lab=UP}
N -710 -760 -710 -610 {
lab=#net8}
N -710 -610 -640 -610 {
lab=#net8}
N -700 -590 -700 -430 {
lab=#net9}
N -700 -590 -650 -590 {
lab=#net9}
N -430 -890 -430 -610 {
lab=#net1}
N -110 -580 -80 -580 {
lab=DN}
N -720 -770 -720 -750 {
lab=#net8}
N -720 -770 -710 -770 {
lab=#net8}
N -710 -770 -710 -760 {
lab=#net8}
N -700 -430 -700 -420 {
lab=#net9}
N -750 -420 -700 -420 {
lab=#net9}
N -100 -790 -100 -560 {
lab=UP}
N -100 -790 0 -790 {
lab=UP}
N 0 -890 0 -790 {
lab=UP}
N -20 -890 0 -890 {
lab=UP}
N -0 -910 0 -890 {
lab=UP}
N 0 -910 20 -910 {
lab=UP}
N -110 -580 -110 -410 {
lab=DN}
N -110 -410 -50 -410 {
lab=DN}
N -50 -410 -50 -360 {
lab=DN}
N 370 -310 370 -290 {
lab=VDD}
N 370 -190 370 -160 {
lab=VSS}
N 220 -520 530 -520 {
lab=#net7}
N 530 -520 530 -240 {
lab=#net7}
N 520 -240 530 -240 {
lab=#net7}
N 150 -220 220 -220 {
lab=S5}
N 110 -240 220 -240 {
lab=LF_OFFCHIP}
N 190 -260 220 -260 {
lab=#net6}
N 190 -300 190 -260 {
lab=#net6}
N 290 -680 290 -520 {
lab=#net7}
N 1150 -500 1270 -500 {
lab=#net2}
N 1270 -600 1270 -500 {
lab=#net2}
N 1270 -600 1330 -600 {
lab=#net2}
N 1150 -470 1330 -470 {
lab=#net3}
N 1330 -470 1330 -390 {
lab=#net3}
N 1330 -390 1340 -390 {
lab=#net3}
N 1520 -600 1560 -600 {
lab=OUT}
N 1530 -390 1570 -390 {
lab=OUTB}
N 1410 -690 1410 -670 {
lab=VDD_TEST}
N 1420 -520 1420 -510 {
lab=VSS}
N 1420 -490 1420 -460 {
lab=VDD_TEST}
N 1430 -310 1430 -290 {
lab=VSS}
N -420 -380 -360 -380 {
lab=#net4}
N -420 -540 -420 -380 {
lab=#net4}
N -420 -580 -420 -540 {
lab=#net4}
N -370 -360 -350 -360 {
lab=DN_INPUT}
N -430 -910 -430 -890 {
lab=#net1}
N -430 -910 -360 -910 {
lab=#net1}
N 1150 -470 1150 -310 {
lab=#net3}
N 1150 -130 1150 -80 {
lab=OUT_D}
N 1220 -240 1260 -240 {
lab=VDD_TEST}
N 1050 -230 1070 -230 {
lab=VSS}
N 810 20 810 60 {
lab=VDD}
N 810 340 810 350 {
lab=VSS}
N 690 120 710 120 {
lab=D6}
N 670 140 710 140 {
lab=D5}
N 660 160 710 160 {
lab=D4}
N 650 180 710 180 {
lab=D3}
N 630 200 710 200 {
lab=D2}
N 600 220 710 220 {
lab=D1}
N 570 240 710 240 {
lab=D0}
N 540 260 710 260 {
lab=IN_DIV}
N 910 290 930 290 {
lab=OUT1_DIV}
N 560 240 570 240 {
lab=D0}
N -1440 -800 -1440 -760 {
lab=VDD}
N -1440 -480 -1440 -470 {
lab=VSS}
N -1560 -700 -1540 -700 {
lab=VSS}
N -1580 -680 -1540 -680 {
lab=VSS}
N -1590 -660 -1540 -660 {
lab=D11}
N -1600 -640 -1540 -640 {
lab=D10}
N -1620 -620 -1540 -620 {
lab=D9}
N -1650 -600 -1540 -600 {
lab=D8}
N -1680 -580 -1540 -580 {
lab=D7}
N -1710 -560 -1540 -560 {
lab=F_IN}
N -1690 -580 -1680 -580 {
lab=D7}
N -1320 -530 -1120 -530 {
lab=OUT1_PRE}
N -1120 -770 -1120 -530 {
lab=OUT1_PRE}
N -1120 -770 -1060 -770 {
lab=OUT1_PRE}
N 1900 30 1900 70 {
lab=VDD}
N 1900 350 1900 360 {
lab=VSS}
N 1780 130 1800 130 {
lab=VSS}
N 1760 150 1800 150 {
lab=VSS}
N 1750 170 1800 170 {
lab=D16}
N 1740 190 1800 190 {
lab=D15}
N 1720 210 1800 210 {
lab=D14}
N 1690 230 1800 230 {
lab=D13}
N 1660 250 1800 250 {
lab=D12}
N 1630 270 1800 270 {
lab=OUT_D}
N 2000 300 2020 300 {
lab=#net10}
N 1650 250 1660 250 {
lab=D12}
N 2020 300 2160 300 {
lab=#net10}
N 2350 300 2390 300 {
lab=OUT1}
N 2240 190 2240 230 {
lab=VDD_TEST}
N 2250 380 2250 410 {
lab=VSS}
N 20 -1000 20 -910 {
lab=UP}
N -1120 -970 -1120 -960 {
lab=PRE_SCALAR}
N -1230 -850 -1190 -850 {
lab=VDD_TEST}
N -1040 -860 -1010 -860 {
lab=VSS}
N 50 -300 190 -300 {
lab=#net6}
N 50 -300 50 -120 {
lab=#net6}
N 50 -120 60 -120 {
lab=#net6}
N -20 -360 -20 -210 {
lab=DN}
N -170 -210 -20 -210 {
lab=DN}
N -170 -210 -170 -150 {
lab=DN}
N -170 30 -170 80 {
lab=DN_OUT}
N -100 -80 -60 -80 {
lab=VDD_TEST}
N -270 -70 -250 -70 {
lab=VSS}
N 930 290 970 290 {
lab=OUT1_DIV}
N 970 290 970 360 {
lab=OUT1_DIV}
N 970 550 970 600 {
lab=DIV_OUT}
N 1040 440 1080 440 {
lab=VDD_TEST}
N 870 450 890 450 {
lab=VSS}
N 20 -1190 20 -1180 {
lab=UP_OUT}
N -90 -1070 -50 -1070 {
lab=VDD_TEST}
N 100 -1080 130 -1080 {
lab=VSS}
N 70 380 120 380 {
lab=OUT_D}
N -40 400 120 400 {
lab=F_IN}
N -130 420 120 420 {
lab=S7}
N 420 400 530 400 {
lab=IN_DIV}
N 530 260 530 400 {
lab=IN_DIV}
N 530 260 540 260 {
lab=IN_DIV}
N 270 310 270 350 {
lab=VDD}
N 270 450 270 490 {
lab=VSS}
N -470 -580 -440 -580 {
lab=#net4}
N -470 -600 -440 -600 {
lab=#net1}
N -440 -610 -440 -600 {
lab=#net1}
N -1340 -530 -1320 -530 {
lab=OUT1_PRE}
N 700 -660 740 -660 {
lab=VCTRL_OBV}
N -1340 -710 -1290 -710 {
lab=P2}
N -1340 -690 -1270 -690 {
lab=LD}
N -1340 -670 -1250 -670 {
lab=Q1}
N -1340 -650 -1230 -650 {
lab=Q2}
N -1340 -630 -1210 -630 {
lab=Q3}
N -1340 -610 -1190 -610 {
lab=Q4}
N -1340 -590 -1170 -590 {
lab=Q5}
N -1340 -570 -1150 -570 {
lab=Q6}
N -1340 -550 -1130 -550 {
lab=Q7}
C {devices/lab_wire.sym} 780 -610 0 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 590 -470 0 0 {name=p11 sig_type=std_logic lab=VCTRL2}
C {devices/lab_wire.sym} 1570 -390 2 0 {name=p21 sig_type=std_logic lab=OUTB}
C {devices/lab_wire.sym} 70 -450 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 70 -630 0 0 {name=p27 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -560 -690 0 0 {name=p31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -560 -510 0 0 {name=p32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 90 -660 0 0 {name=p35 sig_type=std_logic lab=ITAIL}
C {devices/lab_wire.sym} 110 -660 2 0 {name=p36 sig_type=std_logic lab=ITAIL1}
C {devices/lab_wire.sym} 110 -40 0 0 {name=p42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -170 -980 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -200 -440 0 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -170 -810 0 0 {name=p24 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -200 -290 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -360 -340 0 0 {name=p37 sig_type=std_logic lab=S3}
C {devices/lab_wire.sym} -20 -360 1 0 {name=p49 sig_type=std_logic lab=DN}
C {devices/lab_wire.sym} -360 -890 0 0 {name=p54 sig_type=std_logic lab=UP_INPUT}
C {devices/lab_wire.sym} 850 -390 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {PFD_ver_2.sym} -500 -600 0 0 {name=x1}
C {devices/lab_wire.sym} -870 -840 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1060 -730 0 0 {name=p3 sig_type=std_logic lab=S1}
C {devices/lab_wire.sym} -1710 -560 0 0 {name=p4 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} -1060 -750 0 0 {name=p6 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} -900 -510 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1090 -400 0 0 {name=p9 sig_type=std_logic lab=S6}
C {devices/lab_wire.sym} -1090 -440 0 0 {name=p29 sig_type=std_logic lab=DIV_OUT}
C {devices/lab_wire.sym} -870 -670 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -900 -340 0 0 {name=p40 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 800 -1180 0 0 {name=p10 lab=UP_INPUT}
C {devices/ipin.sym} 800 -1150 0 0 {name=p12 lab=DN_INPUT}
C {devices/opin.sym} 800 -1120 0 0 {name=p13 lab=UP_OUT}
C {devices/opin.sym} 800 -1090 0 0 {name=p14 lab=DN_OUT}
C {devices/ipin.sym} 800 -1060 0 0 {name=p15 lab=ITAIL}
C {devices/ipin.sym} 800 -1030 0 0 {name=p16 lab=ITAIL1}
C {devices/ipin.sym} 800 -970 0 0 {name=p18 lab=VCTRL2}
C {devices/opin.sym} 800 -940 0 0 {name=p19 lab=OUT}
C {devices/iopin.sym} 800 -910 0 0 {name=p44 lab=OUTB}
C {devices/iopin.sym} 600 -1180 0 0 {name=p45 lab=VDD}
C {devices/iopin.sym} 600 -1150 0 0 {name=p46 lab=VSS}
C {devices/opin.sym} 600 -1120 0 0 {name=p47 lab=PRE_SCALAR}
C {devices/ipin.sym} 600 -1090 0 0 {name=p50 lab=F_IN}
C {devices/opin.sym} 600 -1060 0 0 {name=p51 lab=DIV_OUT}
C {devices/ipin.sym} 600 -1030 0 0 {name=p52 lab=S1}
C {devices/ipin.sym} 600 -1000 0 0 {name=p53 lab=S6}
C {devices/ipin.sym} 600 -970 0 0 {name=p56 lab=S2}
C {devices/ipin.sym} 600 -940 0 0 {name=p57 lab=S3}
C {devices/lab_wire.sym} 160 110 0 0 {name=p59 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 60 20 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 520 -720 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 520 -590 0 0 {name=p28 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 350 -660 0 0 {name=p33 sig_type=std_logic lab=VCTRL_IN}
C {devices/lab_wire.sym} 340 -640 0 0 {name=p34 sig_type=std_logic lab=S4}
C {devices/ipin.sym} 800 -1000 0 0 {name=p41 lab=VCTRL_IN}
C {devices/ipin.sym} 610 -910 0 0 {name=p58 lab=S4}
C {A_MUX.sym} 520 -660 0 0 {name=x2}
C {VCO_1.sym} 850 -480 0 0 {name=x7}
C {CP.sym} 70 -540 0 0 {name=x8}
C {cap_11p.sym} 60 60 1 0 {name=x9}
C {Res_74k.sym} 260 -70 0 0 {name=x10}
C {cap_240p.sym} 160 140 1 0 {name=x11}
C {A_MUX.sym} -870 -750 0 0 {name=x3}
C {A_MUX.sym} -900 -420 0 0 {name=x4}
C {A_MUX.sym} -200 -360 0 0 {name=x5}
C {A_MUX.sym} -170 -890 0 0 {name=x6}
C {A_MUX.sym} 370 -240 0 0 {name=x12}
C {devices/lab_wire.sym} 370 -310 0 0 {name=p48 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 370 -160 0 0 {name=p62 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 160 -220 0 0 {name=p63 sig_type=std_logic lab=S5}
C {devices/lab_wire.sym} 110 -240 0 0 {name=p64 sig_type=std_logic lab=LF_OFFCHIP}
C {devices/ipin.sym} 610 -880 0 0 {name=p65 lab=S5}
C {devices/ipin.sym} 880 -880 0 0 {name=p66 lab=LF_OFFCHIP}
C {devices/lab_wire.sym} 1560 -600 2 0 {name=p67 sig_type=std_logic lab=OUT}
C {devices/lab_wire.sym} 1410 -690 0 0 {name=p20 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} 1420 -510 2 0 {name=p69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1430 -290 2 0 {name=p70 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -370 -360 0 0 {name=p71 sig_type=std_logic lab=DN_INPUT}
C {devices/lab_wire.sym} -360 -870 0 0 {name=p55 sig_type=std_logic lab=S2}
C {devices/lab_wire.sym} 1050 -230 3 0 {name=p43 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 690 120 0 0 {name=p73 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} 670 140 0 0 {name=p74 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} 660 160 0 0 {name=p75 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} 650 180 0 0 {name=p76 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} 630 200 0 0 {name=p77 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} 600 220 0 0 {name=p78 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 560 240 0 0 {name=p79 sig_type=std_logic lab=D0}
C {devices/lab_wire.sym} 810 20 0 0 {name=p90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 810 350 2 0 {name=p91 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 990 -1190 0 0 {name=p93 lab=D0}
C {devices/ipin.sym} 990 -1160 0 0 {name=p94 lab=D1}
C {devices/ipin.sym} 990 -1130 0 0 {name=p95 lab=D2}
C {devices/ipin.sym} 990 -1100 0 0 {name=p96 lab=D3}
C {devices/ipin.sym} 1000 -1070 0 0 {name=p97 lab=D4}
C {devices/ipin.sym} 1000 -1040 0 0 {name=p98 lab=D5}
C {devices/ipin.sym} 1000 -1000 0 0 {name=p99 lab=D6}
C {devices/ipin.sym} 1000 -970 0 0 {name=p100 lab=D7}
C {devices/ipin.sym} 1000 -940 0 0 {name=p101 lab=D8}
C {devices/ipin.sym} 1000 -910 0 0 {name=p102 lab=D9}
C {devices/ipin.sym} 1010 -880 0 0 {name=p103 lab=D10}
C {devices/ipin.sym} 1010 -850 0 0 {name=p104 lab=D11}
C {devices/ipin.sym} 1080 -1200 0 0 {name=p105 lab=D12}
C {devices/ipin.sym} 1080 -1170 0 0 {name=p106 lab=D13}
C {devices/ipin.sym} 1080 -1140 0 0 {name=p107 lab=D14}
C {devices/ipin.sym} 1080 -1110 0 0 {name=p108 lab=D15}
C {devices/ipin.sym} 1090 -1080 0 0 {name=p109 lab=D16}
C {devices/lab_pin.sym} -1590 -660 0 0 {name=p112 sig_type=std_logic lab=D11}
C {devices/lab_pin.sym} -1600 -640 0 0 {name=p113 sig_type=std_logic lab=D10}
C {devices/lab_pin.sym} -1620 -620 0 0 {name=p114 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} -1650 -600 0 0 {name=p115 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} -1690 -580 0 0 {name=p116 sig_type=std_logic lab=D7}
C {devices/lab_wire.sym} -1440 -800 0 0 {name=p127 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1440 -470 2 0 {name=p128 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -1120 -970 0 0 {name=p110 sig_type=std_logic lab=PRE_SCALAR}
C {devices/lab_wire.sym} -1560 -700 0 0 {name=p111 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -1580 -680 0 0 {name=p117 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1150 -80 0 0 {name=p126 sig_type=std_logic lab=OUT_D}
C {devices/lab_wire.sym} 1780 130 0 0 {name=p130 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1760 150 0 0 {name=p131 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1750 170 0 0 {name=p132 sig_type=std_logic lab=D16}
C {devices/lab_pin.sym} 1740 190 0 0 {name=p133 sig_type=std_logic lab=D15}
C {devices/lab_pin.sym} 1720 210 0 0 {name=p134 sig_type=std_logic lab=D14}
C {devices/lab_pin.sym} 1690 230 0 0 {name=p135 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 1650 250 0 0 {name=p136 sig_type=std_logic lab=D12}
C {devices/lab_pin.sym} 1630 270 0 0 {name=p137 sig_type=std_logic lab=OUT_D}
C {devices/lab_wire.sym} 1900 30 0 0 {name=p147 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1900 360 2 0 {name=p148 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2390 300 2 0 {name=p150 sig_type=std_logic lab=OUT1}
C {devices/lab_wire.sym} 2250 410 2 0 {name=p151 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 800 -840 0 0 {name=p152 lab=OUT1}
C {devices/lab_wire.sym} -1010 -860 2 0 {name=p30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -270 -70 3 0 {name=p61 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -170 80 0 0 {name=p155 sig_type=std_logic lab=DN_OUT}
C {devices/lab_wire.sym} 870 450 3 0 {name=p156 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 970 600 0 0 {name=p158 sig_type=std_logic lab=DIV_OUT}
C {devices/lab_wire.sym} 20 -1190 0 0 {name=p89 sig_type=std_logic lab=UP_OUT}
C {devices/lab_wire.sym} 130 -1080 2 0 {name=p159 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 20 -910 2 0 {name=p160 sig_type=std_logic lab=UP}
C {A_MUX.sym} 270 400 0 0 {name=x24}
C {devices/lab_pin.sym} 70 380 0 0 {name=p161 sig_type=std_logic lab=OUT_D}
C {devices/lab_wire.sym} -40 400 0 0 {name=p162 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} -130 420 0 0 {name=p163 sig_type=std_logic lab=S7}
C {devices/lab_wire.sym} 270 310 0 0 {name=p80 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 270 490 2 0 {name=p164 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 530 400 2 0 {name=p165 sig_type=std_logic lab=IN_DIV}
C {devices/ipin.sym} 620 -850 0 0 {name=p166 lab=S7}
C {devices/iopin.sym} 600 -1210 0 0 {name=p167 lab=VDD_TEST}
C {devices/lab_wire.sym} 1420 -490 0 0 {name=p68 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} 1260 -240 2 0 {name=p72 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} 2240 190 0 0 {name=p146 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} 1080 440 2 0 {name=p157 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} -60 -80 2 0 {name=p154 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} -80 -1070 0 0 {name=p153 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} -1230 -850 0 0 {name=p5 sig_type=std_logic lab=VDD_TEST}
C {devices/lab_wire.sym} 740 -660 2 0 {name=p81 sig_type=std_logic lab=VCTRL_OBV}
C {devices/lab_wire.sym} -1090 -420 0 0 {name=p38 sig_type=std_logic lab=DIV_OUT2}
C {pex_7b_divider_magic.sym} -1390 -620 0 0 {name=x17}
C {devices/ipin.sym} 580 -820 0 0 {name=p82 lab=DIV_OUT2}
C {devices/lab_pin.sym} -1290 -710 2 0 {name=p83 sig_type=std_logic lab=P2}
C {devices/lab_pin.sym} -1270 -690 2 0 {name=p84 sig_type=std_logic lab=LD}
C {devices/lab_pin.sym} -1260 -670 2 0 {name=p85 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} -1240 -650 2 0 {name=p86 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} -1210 -630 2 0 {name=p87 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} -1200 -610 2 0 {name=p88 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} -1170 -590 2 0 {name=p92 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} -1160 -570 2 0 {name=p118 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} -1130 -550 2 0 {name=p119 sig_type=std_logic lab=Q7}
C {pex_7b_divider_magic.sym} 860 200 0 0 {name=x16}
C {pex_7b_divider_magic.sym} 1950 210 0 0 {name=x18}
C {Tappered-Buffer_1_pex.sym} 40 -750 3 0 {name=x14}
C {Tappered-Buffer_1_pex.sym} 1090 -580 0 0 {name=x15}
C {Tappered-Buffer_1_pex.sym} 1100 -370 0 0 {name=x19}
C {Tappered-Buffer_1_pex.sym} 1130 -560 1 0 {name=x20}
C {Tappered-Buffer_1_pex.sym} 1920 320 0 0 {name=x21}
C {Tappered-Buffer_1_pex.sym} 950 120 1 0 {name=x22}
C {Tappered-Buffer_1_pex.sym} -190 -400 1 0 {name=x23}
C {devices/lab_pin.sym} -1270 -530 3 0 {name=p120 sig_type=std_logic lab=OUT1_PRE}
C {devices/lab_pin.sym} 970 300 2 0 {name=p121 sig_type=std_logic lab=OUT1_DIV}
C {Tappered-Buffer_1.sym} -1100 -530 3 0 {name=x13}
