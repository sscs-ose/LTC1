v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {MUX.sym} 90 0 0 0 {name=x1}
C {DFF.sym} 330 -30 0 0 {name=x2}
